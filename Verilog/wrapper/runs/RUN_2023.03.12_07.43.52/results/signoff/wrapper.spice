* NGSPICE file created from wrapper.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_2 abstract view
.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

.subckt wrapper clk_in corner[0] corner[1] corner[2] dac[0] dac[1] dac[2] dac[3] dac[4]
+ dac[5] dac[6] dac[7] dac[8] dac[9] load lock read ref_in reset s_in s_out slope_ctrl[0]
+ slope_ctrl[1] slope_ctrl[2] vbias1[0] vbias1[1] vbias1[2] vbias1[3] vbias1[4] vbias1[5]
+ vbias1[6] vbias1[7] vbias2[0] vbias2[1] vbias2[2] vbias2[3] vbias2[4] vbias2[5]
+ vbias2[6] vbias2[7] vbias3[0] vbias3[1] vbias3[2] vbias3[3] vbias3[4] vbias3[5]
+ vbias3[6] vbias3[7] vco_in vdd vss
X_2037_ clknet_4_11_0_clk_in _0301_ _0066_ vss vss vdd vdd d2.r_reg\[45\] sky130_fd_sc_hd__dfrtp_1
X_2106_ clknet_4_13_0_clk_in _0369_ _0132_ vss vss vdd vdd d2.t_load\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_244 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_177 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_22_188 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_60_228 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_45_225 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_96 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_26_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_26_41 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_13_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_47_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1270_ _0462_ vss vss vdd vdd _0385_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_258 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0985_ d5.fll_core.counter1.count\[9\] vss vss vdd vdd _0780_ sky130_fd_sc_hd__inv_2
X_1606_ net1 vss vss vdd vdd _0684_ sky130_fd_sc_hd__clkbuf_4
X_1537_ _0636_ vss vss vdd vdd _0289_ sky130_fd_sc_hd__clkbuf_1
X_1468_ d2.r_reg\[55\] d2.t_load\[54\] _0586_ vss vss vdd vdd _0589_ sky130_fd_sc_hd__mux2_1
X_1399_ _0541_ vss vss vdd vdd _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_39 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_27_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_357 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_12_76 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_37_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_61 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_56_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1253_ _0976_ vss vss vdd vdd _0393_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_350 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1322_ _0478_ vss vss vdd vdd _0490_ sky130_fd_sc_hd__clkbuf_4
X_1184_ net20 d2.r_reg\[70\] _0934_ vss vss vdd vdd _0940_ sky130_fd_sc_hd__mux2_1
XFILLER_24_239 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_59_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_331 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_261 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_86 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_38_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_176 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_117 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_64_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_345 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_24 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_79 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1871_ _0769_ vss vss vdd vdd _0145_ sky130_fd_sc_hd__inv_2
X_1940_ _0775_ vss vss vdd vdd _0208_ sky130_fd_sc_hd__inv_2
XFILLER_9_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_9_99 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_14_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1236_ _0967_ vss vss vdd vdd _0401_ sky130_fd_sc_hd__clkbuf_1
X_1305_ _0481_ vss vss vdd vdd _0369_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1098_ _0826_ _0886_ _0887_ vss vss vdd vdd _0888_ sky130_fd_sc_hd__a21oi_1
XFILLER_12_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1167_ net28 d2.r_reg\[78\] _0923_ vss vss vdd vdd _0931_ sky130_fd_sc_hd__mux2_1
XFILLER_60_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_20_264 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_28_353 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_34_85 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_34_52 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_34_41 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_507 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_297 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_529 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ clknet_4_0_0_clk_in _0334_ _0099_ vss vss vdd vdd d2.r_reg\[78\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_142 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_150 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1021_ _0815_ vss vss vdd vdd _0816_ sky130_fd_sc_hd__buf_4
XFILLER_34_323 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_342 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1854_ _0767_ vss vss vdd vdd _0130_ sky130_fd_sc_hd__inv_2
X_1785_ _0758_ vss vss vdd vdd _0073_ sky130_fd_sc_hd__inv_2
X_1923_ _0774_ vss vss vdd vdd _0192_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_6_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_6_0_clk_in sky130_fd_sc_hd__clkbuf_8
X_2199_ clknet_1_0__leaf_ref_in _0461_ _0225_ vss vss vdd vdd d5.fll_core.tmp\[9\]
+ sky130_fd_sc_hd__dfrtp_2
X_1219_ d2.t_load\[54\] d2.r_reg\[54\] _0957_ vss vss vdd vdd _0959_ sky130_fd_sc_hd__mux2_1
XFILLER_52_197 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_304 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_356 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_238 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_175 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_16_334 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_31_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1570_ d2.r_reg\[23\] d2.t_load\[22\] _0652_ vss vss vdd vdd _0659_ sky130_fd_sc_hd__mux2_1
XTAP_348 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_234 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2122_ clknet_4_11_0_clk_in _0385_ _0148_ vss vss vdd vdd d2.t_load\[30\] sky130_fd_sc_hd__dfrtp_1
X_2053_ clknet_4_8_0_clk_in _0317_ _0082_ vss vss vdd vdd d2.r_reg\[61\] sky130_fd_sc_hd__dfrtp_1
XTAP_359 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1004_ _0797_ _0798_ vss vss vdd vdd _0799_ sky130_fd_sc_hd__nand2_1
XFILLER_34_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1768_ _0755_ vss vss vdd vdd _0059_ sky130_fd_sc_hd__inv_2
X_1837_ _0765_ vss vss vdd vdd _0353_ sky130_fd_sc_hd__clkbuf_1
X_1906_ _0772_ vss vss vdd vdd _0177_ sky130_fd_sc_hd__inv_2
X_1699_ _0736_ _0737_ vss vss vdd vdd _0007_ sky130_fd_sc_hd__nor2_1
XFILLER_25_131 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_13_326 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xoutput7 net7 vss vss vdd vdd corner[2] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net20 vss vss vdd vdd slope_ctrl[2] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net42 vss vss vdd vdd vbias3[5] sky130_fd_sc_hd__clkbuf_1
XFILLER_31_86 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xoutput31 net31 vss vss vdd vdd vbias2[2] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_61 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_0_274 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_16_153 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_16_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1622_ _0694_ d2.r_reg\[6\] _0684_ vss vss vdd vdd _0695_ sky130_fd_sc_hd__mux2_1
X_1553_ _0647_ vss vss vdd vdd _0284_ sky130_fd_sc_hd__clkbuf_1
X_1484_ d2.r_reg\[50\] d2.t_load\[49\] _0586_ vss vss vdd vdd _0600_ sky130_fd_sc_hd__mux2_1
XTAP_178 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2036_ clknet_4_11_0_clk_in _0300_ _0065_ vss vss vdd vdd d2.r_reg\[44\] sky130_fd_sc_hd__dfrtp_1
X_2105_ clknet_4_13_0_clk_in _0368_ _0131_ vss vss vdd vdd d2.t_load\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_45_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_42_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_42_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_322 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_229 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1536_ _0635_ d2.r_reg\[33\] _0618_ vss vss vdd vdd _0636_ sky130_fd_sc_hd__mux2_1
X_1605_ d2.r_reg\[12\] d2.t_load\[11\] _0674_ vss vss vdd vdd _0683_ sky130_fd_sc_hd__mux2_1
XFILLER_8_171 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1467_ _0588_ vss vss vdd vdd _0311_ sky130_fd_sc_hd__clkbuf_1
X_1398_ _0540_ d2.r_reg\[76\] _0530_ vss vss vdd vdd _0541_ sky130_fd_sc_hd__mux2_1
X_2019_ clknet_4_14_0_clk_in _0283_ _0048_ vss vss vdd vdd d2.r_reg\[27\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_119 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_126 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_58_351 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_218 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_18_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1252_ d2.t_load\[38\] d2.r_reg\[38\] _0968_ vss vss vdd vdd _0976_ sky130_fd_sc_hd__mux2_1
X_1321_ _0489_ vss vss vdd vdd _0361_ sky130_fd_sc_hd__clkbuf_1
Xwrapper_45 vss vss vdd vdd wrapper_45/HI dac[8] sky130_fd_sc_hd__conb_1
XFILLER_64_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_354 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_17_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_292 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1183_ _0939_ vss vss vdd vdd _0426_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1519_ d2.r_reg\[39\] d2.t_load\[38\] _0608_ vss vss vdd vdd _0624_ sky130_fd_sc_hd__mux2_1
XFILLER_23_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_188 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_133 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_61_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_61_324 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_365 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1870_ _0769_ vss vss vdd vdd _0144_ sky130_fd_sc_hd__inv_2
XFILLER_43_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_129 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1235_ d2.t_load\[46\] d2.r_reg\[46\] _0957_ vss vss vdd vdd _0967_ sky130_fd_sc_hd__mux2_1
X_1304_ d2.t_load\[14\] d2.r_reg\[14\] _0479_ vss vss vdd vdd _0481_ sky130_fd_sc_hd__mux2_1
XFILLER_37_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1166_ _0930_ vss vss vdd vdd _0434_ sky130_fd_sc_hd__clkbuf_1
X_1097_ d5.fll_core.tmp\[6\] _0817_ vss vss vdd vdd _0887_ sky130_fd_sc_hd__and2_1
XFILLER_20_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1999_ clknet_4_6_0_clk_in _0263_ _0028_ vss vss vdd vdd d2.r_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_387 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_28_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_225 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_519 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1020_ _0810_ _0814_ vss vss vdd vdd _0815_ sky130_fd_sc_hd__nor2_1
XFILLER_19_310 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_173 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_313 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1922_ _0774_ vss vss vdd vdd _0191_ sky130_fd_sc_hd__inv_2
X_1784_ _0758_ vss vss vdd vdd _0072_ sky130_fd_sc_hd__inv_2
X_1853_ _0767_ vss vss vdd vdd _0129_ sky130_fd_sc_hd__inv_2
XFILLER_52_132 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2198_ clknet_1_0__leaf_ref_in _0460_ _0224_ vss vss vdd vdd d5.fll_core.tmp\[8\]
+ sky130_fd_sc_hd__dfrtp_2
X_1218_ _0958_ vss vss vdd vdd _0410_ sky130_fd_sc_hd__clkbuf_1
X_1149_ _0921_ vss vss vdd vdd _0442_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_198 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_184 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_173 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_313 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_61_95 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_61_84 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_349 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_294 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_305 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2121_ clknet_4_14_0_clk_in _0384_ _0147_ vss vss vdd vdd d2.t_load\[29\] sky130_fd_sc_hd__dfrtp_1
X_1003_ d2.t_load\[23\] d5.fll_core.counter1.count\[3\] vss vss vdd vdd _0798_ sky130_fd_sc_hd__or2b_1
X_2052_ clknet_4_8_0_clk_in _0316_ _0081_ vss vss vdd vdd d2.r_reg\[60\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_371 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1905_ _0772_ vss vss vdd vdd _0176_ sky130_fd_sc_hd__inv_2
XFILLER_22_349 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1698_ d5.fll_core.counter1.count\[6\] _0734_ vss vss vdd vdd _0737_ sky130_fd_sc_hd__nor2_1
X_1767_ _0755_ vss vss vdd vdd _0058_ sky130_fd_sc_hd__inv_2
X_1836_ d5.fll_core.corner_tmp\[1\] _0763_ vss vss vdd vdd _0765_ sky130_fd_sc_hd__and2_1
XFILLER_66_29 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_25_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_31_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xoutput10 net10 vss vss vdd vdd dac[2] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net8 vss vss vdd vdd dac[0] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net43 vss vss vdd vdd vbias3[6] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xoutput21 net21 vss vss vdd vdd vbias1[0] sky130_fd_sc_hd__clkbuf_1
Xoutput32 net32 vss vss vdd vdd vbias2[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_63_205 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_121 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_31_124 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_31_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_360 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_165 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1552_ _0646_ d2.r_reg\[28\] _0640_ vss vss vdd vdd _0647_ sky130_fd_sc_hd__mux2_1
X_1621_ d2.r_reg\[7\] d2.t_load\[6\] _0674_ vss vss vdd vdd _0694_ sky130_fd_sc_hd__mux2_1
XFILLER_39_257 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1483_ _0599_ vss vss vdd vdd _0306_ sky130_fd_sc_hd__clkbuf_1
X_2104_ clknet_4_13_0_clk_in _0367_ _0130_ vss vss vdd vdd d2.t_load\[12\] sky130_fd_sc_hd__dfrtp_1
XTAP_179 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_205 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2035_ clknet_4_9_0_clk_in _0299_ _0064_ vss vss vdd vdd d2.r_reg\[43\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_22_157 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1819_ _0761_ vss vss vdd vdd _0104_ sky130_fd_sc_hd__inv_2
XFILLER_60_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_128 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_5_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_69 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1535_ d2.r_reg\[34\] d2.t_load\[33\] _0630_ vss vss vdd vdd _0635_ sky130_fd_sc_hd__mux2_1
X_1604_ _0682_ vss vss vdd vdd _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_183 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_205 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1466_ _0587_ d2.r_reg\[55\] _0574_ vss vss vdd vdd _0588_ sky130_fd_sc_hd__mux2_1
X_1397_ d2.r_reg\[77\] net26 _0520_ vss vss vdd vdd _0540_ sky130_fd_sc_hd__mux2_1
X_2018_ clknet_4_14_0_clk_in _0282_ _0047_ vss vss vdd vdd d2.r_reg\[26\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_285 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_260 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_105 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_296 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_241 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1320_ d2.t_load\[6\] d2.r_reg\[6\] _0479_ vss vss vdd vdd _0489_ sky130_fd_sc_hd__mux2_1
XFILLER_5_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1251_ _0975_ vss vss vdd vdd _0394_ sky130_fd_sc_hd__clkbuf_1
X_1182_ net21 d2.r_reg\[71\] _0934_ vss vss vdd vdd _0939_ sky130_fd_sc_hd__mux2_1
Xwrapper_46 vss vss vdd vdd wrapper_46/HI dac[9] sky130_fd_sc_hd__conb_1
XFILLER_64_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1518_ _0623_ vss vss vdd vdd _0295_ sky130_fd_sc_hd__clkbuf_1
X_1449_ d2.r_reg\[61\] d2.t_load\[60\] _0564_ vss vss vdd vdd _0576_ sky130_fd_sc_hd__mux2_1
XFILLER_55_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_23_274 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_3_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_48_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_0_37 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1303_ _0480_ vss vss vdd vdd _0370_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_163 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_64_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1234_ _0966_ vss vss vdd vdd _0402_ sky130_fd_sc_hd__clkbuf_1
X_1096_ _0825_ _0827_ _0828_ _0831_ _0817_ vss vss vdd vdd _0886_ sky130_fd_sc_hd__a32o_1
X_1165_ net29 d2.r_reg\[79\] _0923_ vss vss vdd vdd _0930_ sky130_fd_sc_hd__mux2_1
XFILLER_60_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_347 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_233 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1998_ clknet_4_6_0_clk_in _0262_ _0027_ vss vss vdd vdd d2.r_reg\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_299 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_303 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_50_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_34_76 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_7_237 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_73 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_509 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_19_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_177 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_111 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_336 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1852_ _0767_ vss vss vdd vdd _0128_ sky130_fd_sc_hd__inv_2
X_1921_ _0750_ vss vss vdd vdd _0774_ sky130_fd_sc_hd__buf_4
X_1783_ _0758_ vss vss vdd vdd _0071_ sky130_fd_sc_hd__inv_2
XFILLER_6_281 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_122 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_174 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2197_ clknet_1_0__leaf_ref_in _0459_ _0223_ vss vss vdd vdd d5.fll_core.tmp\[7\]
+ sky130_fd_sc_hd__dfrtp_2
X_1217_ d2.t_load\[55\] d2.r_reg\[55\] _0957_ vss vss vdd vdd _0958_ sky130_fd_sc_hd__mux2_1
X_1079_ d2.t_load\[4\] d5.fll_core.counter2.count\[4\] vss vss vdd vdd _0872_ sky130_fd_sc_hd__xor2_1
X_1148_ net37 d2.r_reg\[87\] _0912_ vss vss vdd vdd _0921_ sky130_fd_sc_hd__mux2_1
XFILLER_52_188 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_28_152 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_63 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_225 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2120_ clknet_4_14_0_clk_in _0383_ _0146_ vss vss vdd vdd d2.t_load\[28\] sky130_fd_sc_hd__dfrtp_1
XTAP_339 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_262 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XTAP_306 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_258 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1002_ d2.t_load\[22\] d5.fll_core.counter1.count\[2\] vss vss vdd vdd _0797_ sky130_fd_sc_hd__or2b_1
XFILLER_34_166 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2051_ clknet_4_3_0_clk_in _0315_ _0080_ vss vss vdd vdd d2.r_reg\[59\] sky130_fd_sc_hd__dfrtp_1
X_1835_ _0764_ vss vss vdd vdd _0352_ sky130_fd_sc_hd__clkbuf_1
X_1904_ _0772_ vss vss vdd vdd _0175_ sky130_fd_sc_hd__inv_2
XFILLER_15_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1766_ _0755_ vss vss vdd vdd _0057_ sky130_fd_sc_hd__inv_2
X_1697_ d5.fll_core.counter1.count\[6\] _0734_ vss vss vdd vdd _0736_ sky130_fd_sc_hd__and2_1
XFILLER_57_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_188 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_100 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xoutput11 net11 vss vss vdd vdd dac[3] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 vss vss vdd vdd dac[1] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net44 vss vss vdd vdd vbias3[7] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
Xoutput33 net33 vss vss vdd vdd vbias2[4] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net22 vss vss vdd vdd vbias1[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_85 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_48_258 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_100 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_169 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_16_177 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1551_ d2.r_reg\[29\] d2.t_load\[28\] _0630_ vss vss vdd vdd _0646_ sky130_fd_sc_hd__mux2_1
X_1482_ _0598_ d2.r_reg\[50\] _0596_ vss vss vdd vdd _0599_ sky130_fd_sc_hd__mux2_1
X_1620_ _0693_ vss vss vdd vdd _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_39_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_39_203 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2103_ clknet_4_13_0_clk_in _0366_ _0129_ vss vss vdd vdd d2.t_load\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_169 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2034_ clknet_4_8_0_clk_in _0298_ _0063_ vss vss vdd vdd d2.r_reg\[42\] sky130_fd_sc_hd__dfrtp_1
X_1818_ _0761_ vss vss vdd vdd _0103_ sky130_fd_sc_hd__inv_2
XFILLER_10_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1749_ _0754_ vss vss vdd vdd _0041_ sky130_fd_sc_hd__inv_2
XFILLER_26_55 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_302 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_44_294 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_3 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_8_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1534_ _0634_ vss vss vdd vdd _0290_ sky130_fd_sc_hd__clkbuf_1
X_1603_ _0681_ d2.r_reg\[12\] _0662_ vss vss vdd vdd _0682_ sky130_fd_sc_hd__mux2_1
X_1465_ d2.r_reg\[56\] d2.t_load\[55\] _0586_ vss vss vdd vdd _0587_ sky130_fd_sc_hd__mux2_1
X_2017_ clknet_4_15_0_clk_in _0281_ _0046_ vss vss vdd vdd d2.r_reg\[25\] sky130_fd_sc_hd__dfrtp_1
X_1396_ _0539_ vss vss vdd vdd _0333_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_231 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_5_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_64_301 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1250_ d2.t_load\[39\] d2.r_reg\[39\] _0968_ vss vss vdd vdd _0975_ sky130_fd_sc_hd__mux2_1
XFILLER_49_386 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1181_ _0938_ vss vss vdd vdd _0427_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_253 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_32_220 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1517_ _0622_ d2.r_reg\[39\] _0618_ vss vss vdd vdd _0623_ sky130_fd_sc_hd__mux2_1
X_1448_ _0575_ vss vss vdd vdd _0317_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1379_ _0527_ d2.r_reg\[82\] _0508_ vss vss vdd vdd _0528_ sky130_fd_sc_hd__mux2_1
XFILLER_23_286 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_301 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_49 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_64_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_64_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_337 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_9_69 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_14_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_14_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1233_ d2.t_load\[47\] d2.r_reg\[47\] _0957_ vss vss vdd vdd _0966_ sky130_fd_sc_hd__mux2_1
X_1302_ d2.t_load\[15\] d2.r_reg\[15\] _0479_ vss vss vdd vdd _0480_ sky130_fd_sc_hd__mux2_1
XFILLER_29_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_37_323 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1095_ _0885_ vss vss vdd vdd _0460_ sky130_fd_sc_hd__clkbuf_1
X_1164_ _0929_ vss vss vdd vdd _0435_ sky130_fd_sc_hd__clkbuf_1
X_1997_ clknet_4_6_0_clk_in _0261_ _0026_ vss vss vdd vdd d2.r_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_11_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_11_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_55_142 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_45 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_51_381 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_43_337 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xclkbuf_0_clk_in clk_in vss vss vdd vdd clknet_0_clk_in sky130_fd_sc_hd__clkbuf_16
XFILLER_11_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_65 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_99 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_7_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_249 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_46_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_42_392 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1851_ _0767_ vss vss vdd vdd _0127_ sky130_fd_sc_hd__inv_2
Xclkbuf_1_0__f_ref_in clknet_0_ref_in vss vss vdd vdd clknet_1_0__leaf_ref_in sky130_fd_sc_hd__clkbuf_16
X_1920_ _0773_ vss vss vdd vdd _0190_ sky130_fd_sc_hd__inv_2
X_1782_ _0757_ vss vss vdd vdd _0758_ sky130_fd_sc_hd__buf_4
X_2196_ clknet_1_0__leaf_ref_in _0458_ _0222_ vss vss vdd vdd d5.fll_core.tmp\[6\]
+ sky130_fd_sc_hd__dfrtp_2
X_1216_ _0911_ vss vss vdd vdd _0957_ sky130_fd_sc_hd__clkbuf_4
XFILLER_52_156 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_164 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_326 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1147_ _0920_ vss vss vdd vdd _0443_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_81 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1078_ d2.t_load\[5\] vss vss vdd vdd _0871_ sky130_fd_sc_hd__inv_2
XFILLER_43_134 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_29_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_197 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_28_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_120 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_43_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_156 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_392 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_24_381 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_204 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_329 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ clknet_4_3_0_clk_in _0314_ _0079_ vss vss vdd vdd d2.r_reg\[58\] sky130_fd_sc_hd__dfrtp_1
XTAP_307 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1001_ d5.fll_core.counter1.count\[3\] d2.t_load\[23\] vss vss vdd vdd _0796_ sky130_fd_sc_hd__or2b_1
XFILLER_34_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_112 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1765_ _0755_ vss vss vdd vdd _0056_ sky130_fd_sc_hd__inv_2
X_1834_ _0817_ d5.fll_core.corner_tmp\[0\] _0763_ vss vss vdd vdd _0764_ sky130_fd_sc_hd__mux2_1
X_1903_ _0772_ vss vss vdd vdd _0174_ sky130_fd_sc_hd__inv_2
X_1696_ _0734_ _0735_ vss vss vdd vdd _0006_ sky130_fd_sc_hd__nor2_1
XFILLER_65_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_57_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2179_ clknet_4_5_0_clk_in _0442_ _0205_ vss vss vdd vdd net37 sky130_fd_sc_hd__dfrtp_1
XFILLER_15_57 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xoutput12 net12 vss vss vdd vdd dac[4] sky130_fd_sc_hd__clkbuf_1
Xoutput34 net34 vss vss vdd vdd vbias2[5] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net23 vss vss vdd vdd vbias1[2] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_299 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_0_233 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_63_218 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_56_53 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_189 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_8_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1550_ _0645_ vss vss vdd vdd _0285_ sky130_fd_sc_hd__clkbuf_1
X_1481_ d2.r_reg\[51\] d2.t_load\[50\] _0586_ vss vss vdd vdd _0598_ sky130_fd_sc_hd__mux2_1
XTAP_148 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2033_ clknet_4_10_0_clk_in _0297_ _0062_ vss vss vdd vdd d2.r_reg\[41\] sky130_fd_sc_hd__dfrtp_1
XFILLER_47_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2102_ clknet_4_13_0_clk_in _0365_ _0128_ vss vss vdd vdd d2.t_load\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_159 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_62_295 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_284 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_62_251 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_22_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1748_ _0751_ vss vss vdd vdd _0754_ sky130_fd_sc_hd__buf_4
X_1817_ _0761_ vss vss vdd vdd _0102_ sky130_fd_sc_hd__inv_2
X_1679_ _0726_ vss vss vdd vdd net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_38_281 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_77 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_13_126 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_137 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_21_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_29_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_29_270 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_59_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1602_ d2.r_reg\[13\] d2.t_load\[12\] _0674_ vss vss vdd vdd _0681_ sky130_fd_sc_hd__mux2_1
XFILLER_8_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_8_152 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1533_ _0633_ d2.r_reg\[34\] _0618_ vss vss vdd vdd _0634_ sky130_fd_sc_hd__mux2_1
X_1464_ net2 vss vss vdd vdd _0586_ sky130_fd_sc_hd__clkbuf_4
X_1395_ _0538_ d2.r_reg\[77\] _0530_ vss vss vdd vdd _0539_ sky130_fd_sc_hd__mux2_1
X_2016_ clknet_4_15_0_clk_in _0280_ _0045_ vss vss vdd vdd d2.r_reg\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_221 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_58_376 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_58_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_58_343 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_490 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_41_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_99 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_41_287 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_49_321 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_310 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_1_361 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1180_ net22 d2.r_reg\[72\] _0934_ vss vss vdd vdd _0938_ sky130_fd_sc_hd__mux2_1
XFILLER_32_298 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_243 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1516_ d2.r_reg\[40\] d2.t_load\[39\] _0608_ vss vss vdd vdd _0622_ sky130_fd_sc_hd__mux2_1
Xclkbuf_4_9_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_9_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_55_324 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1447_ _0573_ d2.r_reg\[61\] _0574_ vss vss vdd vdd _0575_ sky130_fd_sc_hd__mux2_1
X_1378_ d2.r_reg\[83\] net32 _0520_ vss vss vdd vdd _0527_ sky130_fd_sc_hd__mux2_1
XFILLER_55_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_23_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_23_79 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_64_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_305 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_58_151 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_65 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_9_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_14_221 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_14_243 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_298 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_151 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1232_ _0965_ vss vss vdd vdd _0403_ sky130_fd_sc_hd__clkbuf_1
X_1301_ _0478_ vss vss vdd vdd _0479_ sky130_fd_sc_hd__clkbuf_4
XFILLER_64_187 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1094_ d5.fll_core.tmp\[8\] _0884_ _0881_ vss vss vdd vdd _0885_ sky130_fd_sc_hd__mux2_1
X_1163_ net30 d2.r_reg\[80\] _0923_ vss vss vdd vdd _0929_ sky130_fd_sc_hd__mux2_1
X_1996_ clknet_4_6_0_clk_in _0260_ _0025_ vss vss vdd vdd d2.r_reg\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_55_132 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_55_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_187 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_51_360 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_34_89 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_7_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_59_86 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_34_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_42_382 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1850_ _0767_ vss vss vdd vdd _0126_ sky130_fd_sc_hd__inv_2
X_1781_ _0750_ vss vss vdd vdd _0757_ sky130_fd_sc_hd__buf_4
XFILLER_41_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_294 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2195_ clknet_1_1__leaf_ref_in _0457_ _0221_ vss vss vdd vdd d5.fll_core.tmp\[5\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_37_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1215_ _0956_ vss vss vdd vdd _0411_ sky130_fd_sc_hd__clkbuf_1
X_1146_ net38 d2.r_reg\[88\] _0912_ vss vss vdd vdd _0920_ sky130_fd_sc_hd__mux2_1
XFILLER_37_187 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_349 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1077_ d5.fll_core.counter2.count\[0\] vss vss vdd vdd _0011_ sky130_fd_sc_hd__inv_2
XFILLER_1_93 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1979_ _0779_ vss vss vdd vdd _0243_ sky130_fd_sc_hd__inv_2
XFILLER_4_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_45_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_319 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_286 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1000_ _0786_ d5.fll_core.counter1.count\[4\] _0789_ _0792_ _0794_ vss vss vdd vdd
+ _0795_ sky130_fd_sc_hd__o2111a_1
XFILLER_20_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_19_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1902_ _0772_ vss vss vdd vdd _0173_ sky130_fd_sc_hd__inv_2
X_1764_ _0755_ vss vss vdd vdd _0055_ sky130_fd_sc_hd__inv_2
X_1833_ _0750_ _0860_ _0000_ vss vss vdd vdd _0763_ sky130_fd_sc_hd__or3b_1
XFILLER_30_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1695_ d5.fll_core.counter1.count\[4\] _0732_ d5.fll_core.counter1.count\[5\] vss
+ vss vdd vdd _0735_ sky130_fd_sc_hd__a21oi_1
X_1129_ _0910_ vss vss vdd vdd _0451_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2178_ clknet_4_4_0_clk_in _0441_ _0204_ vss vss vdd vdd net36 sky130_fd_sc_hd__dfrtp_1
XFILLER_40_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_13_319 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_330 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xoutput13 net13 vss vss vdd vdd dac[5] sky130_fd_sc_hd__clkbuf_1
XFILLER_31_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xoutput35 net35 vss vss vdd vdd vbias2[6] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net24 vss vss vdd vdd vbias1[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_267 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_130 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_56_271 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_8_334 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_216 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1480_ _0597_ vss vss vdd vdd _0307_ sky130_fd_sc_hd__clkbuf_1
XTAP_149 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_230 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2032_ clknet_4_8_0_clk_in _0296_ _0061_ vss vss vdd vdd d2.r_reg\[40\] sky130_fd_sc_hd__dfrtp_1
X_2101_ clknet_4_7_0_clk_in _0364_ _0127_ vss vss vdd vdd d2.t_load\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_149 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1678_ d2.t_load\[63\] d2.t_load\[39\] d2.t_load\[44\] vss vss vdd vdd _0726_ sky130_fd_sc_hd__mux2_1
X_1747_ _0753_ vss vss vdd vdd _0040_ sky130_fd_sc_hd__inv_2
XFILLER_7_81 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1816_ _0761_ vss vss vdd vdd _0101_ sky130_fd_sc_hd__inv_2
XFILLER_26_68 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_315 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_36_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1532_ d2.r_reg\[35\] d2.t_load\[34\] _0630_ vss vss vdd vdd _0633_ sky130_fd_sc_hd__mux2_1
X_1601_ _0680_ vss vss vdd vdd _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_8_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1394_ d2.r_reg\[78\] net27 _0520_ vss vss vdd vdd _0538_ sky130_fd_sc_hd__mux2_1
X_1463_ _0585_ vss vss vdd vdd _0312_ sky130_fd_sc_hd__clkbuf_1
X_2015_ clknet_4_15_0_clk_in _0279_ _0044_ vss vss vdd vdd d2.r_reg\[23\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_274 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_50_244 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_12_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_58_388 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_322 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_491 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_99 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_1_373 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_347 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1515_ _0621_ vss vss vdd vdd _0296_ sky130_fd_sc_hd__clkbuf_1
X_1446_ _0478_ vss vss vdd vdd _0574_ sky130_fd_sc_hd__clkbuf_4
X_1377_ _0526_ vss vss vdd vdd _0339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_23_222 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_58_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_64_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_46_369 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_347 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_29 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_14_288 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_174 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1231_ d2.t_load\[48\] d2.r_reg\[48\] _0957_ vss vss vdd vdd _0965_ sky130_fd_sc_hd__mux2_1
XFILLER_37_303 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1162_ _0928_ vss vss vdd vdd _0436_ sky130_fd_sc_hd__clkbuf_1
X_1300_ net1 vss vss vdd vdd _0478_ sky130_fd_sc_hd__buf_4
XFILLER_52_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1093_ _0883_ _0833_ vss vss vdd vdd _0884_ sky130_fd_sc_hd__xnor2_1
XFILLER_9_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_292 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1995_ clknet_4_6_0_clk_in _0259_ _0024_ vss vss vdd vdd d2.r_reg\[3\] sky130_fd_sc_hd__dfrtp_1
X_1429_ d2.r_reg\[67\] d2.t_load\[66\] _0542_ vss vss vdd vdd _0562_ sky130_fd_sc_hd__mux2_1
XFILLER_55_177 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_155 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_328 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_43_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_11_225 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_169 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_177 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_380 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1780_ _0756_ vss vss vdd vdd _0070_ sky130_fd_sc_hd__inv_2
XFILLER_6_251 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2194_ clknet_1_1__leaf_ref_in _0456_ _0220_ vss vss vdd vdd d5.fll_core.tmp\[4\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_25_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1214_ d2.t_load\[56\] d2.r_reg\[56\] _0945_ vss vss vdd vdd _0956_ sky130_fd_sc_hd__mux2_1
X_1145_ _0919_ vss vss vdd vdd _0444_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_350 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1076_ d2.t_load\[6\] _0865_ d5.fll_core.counter2.count\[8\] _0866_ _0869_ vss vss
+ vdd vdd _0870_ sky130_fd_sc_hd__o221a_1
X_1978_ _0779_ vss vss vdd vdd _0242_ sky130_fd_sc_hd__inv_2
XFILLER_29_57 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_89 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_169 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_31_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_51_180 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_309 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_353 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1901_ _0772_ vss vss vdd vdd _0172_ sky130_fd_sc_hd__inv_2
X_1832_ _0762_ vss vss vdd vdd _0116_ sky130_fd_sc_hd__inv_2
XFILLER_15_361 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_22_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1763_ _0755_ vss vss vdd vdd _0054_ sky130_fd_sc_hd__inv_2
X_1694_ d5.fll_core.counter1.count\[5\] d5.fll_core.counter1.count\[4\] _0732_ vss
+ vss vdd vdd _0734_ sky130_fd_sc_hd__and3_1
X_1059_ _0816_ _0852_ vss vss vdd vdd _0853_ sky130_fd_sc_hd__nor2_1
X_1128_ d5.fll_core.locked _0853_ _0000_ vss vss vdd vdd _0910_ sky130_fd_sc_hd__mux2_1
XFILLER_40_117 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_25_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_125 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2177_ clknet_4_1_0_clk_in _0440_ _0203_ vss vss vdd vdd net35 sky130_fd_sc_hd__dfrtp_1
XFILLER_13_309 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_15_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_33_191 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xoutput14 net14 vss vss vdd vdd dac[6] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net25 vss vss vdd vdd vbias1[4] sky130_fd_sc_hd__clkbuf_1
Xoutput36 net36 vss vss vdd vdd vbias2[7] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_213 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_56_283 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_131 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_120 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_56_294 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_180 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_8_302 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_8_313 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_8_346 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2100_ clknet_4_7_0_clk_in _0363_ _0126_ vss vss vdd vdd d2.t_load\[8\] sky130_fd_sc_hd__dfrtp_1
XTAP_139 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2031_ clknet_4_10_0_clk_in _0295_ _0060_ vss vss vdd vdd d2.r_reg\[39\] sky130_fd_sc_hd__dfrtp_1
XPHY_0 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_22_106 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1815_ _0757_ vss vss vdd vdd _0761_ sky130_fd_sc_hd__buf_4
X_1677_ _0725_ vss vss vdd vdd net12 sky130_fd_sc_hd__clkbuf_1
X_1746_ _0753_ vss vss vdd vdd _0039_ sky130_fd_sc_hd__inv_2
XFILLER_7_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2229_ d5.fll_core.strobe d5.mux01.out\[9\] _0255_ vss vss vdd vdd d2.t_load\[67\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_297 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_161 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_44_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_29_294 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1531_ _0632_ vss vss vdd vdd _0291_ sky130_fd_sc_hd__clkbuf_1
X_1600_ _0679_ d2.r_reg\[13\] _0662_ vss vss vdd vdd _0680_ sky130_fd_sc_hd__mux2_1
X_1462_ _0584_ d2.r_reg\[56\] _0574_ vss vss vdd vdd _0585_ sky130_fd_sc_hd__mux2_1
X_1393_ _0537_ vss vss vdd vdd _0334_ sky130_fd_sc_hd__clkbuf_1
X_2014_ clknet_4_15_0_clk_in _0278_ _0043_ vss vss vdd vdd d2.r_reg\[22\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_264 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_35_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_278 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_12_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1729_ _0752_ vss vss vdd vdd _0023_ sky130_fd_sc_hd__inv_2
XTAP_492 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_26_253 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_242 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_41_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_234 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_1_385 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_286 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_64_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_32_278 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1514_ _0620_ d2.r_reg\[40\] _0618_ vss vss vdd vdd _0621_ sky130_fd_sc_hd__mux2_1
X_1445_ d2.r_reg\[62\] d2.t_load\[61\] _0564_ vss vss vdd vdd _0573_ sky130_fd_sc_hd__mux2_1
XFILLER_4_94 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_55_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1376_ _0525_ d2.r_reg\[83\] _0508_ vss vss vdd vdd _0526_ sky130_fd_sc_hd__mux2_1
XFILLER_23_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_58_164 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_120 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_46_315 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_149 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_64_77 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_58_197 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_370 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_134 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1230_ _0964_ vss vss vdd vdd _0404_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_348 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1092_ _0834_ _0818_ vss vss vdd vdd _0883_ sky130_fd_sc_hd__or2b_1
XFILLER_37_315 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_1_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1161_ net31 d2.r_reg\[81\] _0923_ vss vss vdd vdd _0928_ sky130_fd_sc_hd__mux2_1
XFILLER_52_318 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1994_ clknet_4_6_0_clk_in _0258_ _0023_ vss vss vdd vdd d2.r_reg\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_20_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1428_ _0561_ vss vss vdd vdd _0323_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1359_ d2.r_reg\[89\] net38 _0498_ vss vss vdd vdd _0514_ sky130_fd_sc_hd__mux2_1
XFILLER_11_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_66 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_167 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_19_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_91 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1213_ _0955_ vss vss vdd vdd _0412_ sky130_fd_sc_hd__clkbuf_1
XFILLER_27_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_104 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2193_ clknet_1_1__leaf_ref_in _0455_ _0219_ vss vss vdd vdd d5.fll_core.tmp\[3\]
+ sky130_fd_sc_hd__dfrtp_2
X_1075_ d2.t_load\[1\] _0867_ _0868_ d2.t_load\[7\] vss vss vdd vdd _0869_ sky130_fd_sc_hd__a22oi_1
X_1144_ net39 d2.r_reg\[89\] _0912_ vss vss vdd vdd _0919_ sky130_fd_sc_hd__mux2_1
X_1977_ _0779_ vss vss vdd vdd _0241_ sky130_fd_sc_hd__inv_2
XFILLER_28_156 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_45_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_43_126 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_24_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_34_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_19_101 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_19_123 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_42_192 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1900_ _0772_ vss vss vdd vdd _0171_ sky130_fd_sc_hd__inv_2
XFILLER_30_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_373 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1831_ _0762_ vss vss vdd vdd _0115_ sky130_fd_sc_hd__inv_2
X_1762_ _0755_ vss vss vdd vdd _0053_ sky130_fd_sc_hd__inv_2
X_1693_ _0793_ _0732_ vss vss vdd vdd _0005_ sky130_fd_sc_hd__xnor2_1
XFILLER_57_207 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2176_ clknet_4_1_0_clk_in _0439_ _0202_ vss vss vdd vdd net34 sky130_fd_sc_hd__dfrtp_1
X_1058_ d2.t_load\[19\] _0780_ _0850_ _0851_ vss vss vdd vdd _0852_ sky130_fd_sc_hd__a22o_1
X_1127_ d5.fll_core.tmp\[0\] _0881_ vss vss vdd vdd _0452_ sky130_fd_sc_hd__xor2_1
XFILLER_15_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_31_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
Xoutput15 net15 vss vss vdd vdd dac[7] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net26 vss vss vdd vdd vbias1[5] sky130_fd_sc_hd__clkbuf_1
Xoutput37 net37 vss vss vdd vdd vbias3[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_258 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_132 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_121 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_110 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_12_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_358 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2030_ clknet_4_10_0_clk_in _0294_ _0059_ vss vss vdd vdd d2.r_reg\[38\] sky130_fd_sc_hd__dfrtp_1
XFILLER_47_262 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_1 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1745_ _0753_ vss vss vdd vdd _0038_ sky130_fd_sc_hd__inv_2
XFILLER_15_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1814_ _0760_ vss vss vdd vdd _0100_ sky130_fd_sc_hd__inv_2
X_1676_ d2.t_load\[62\] d2.t_load\[38\] d2.t_load\[44\] vss vss vdd vdd _0725_ sky130_fd_sc_hd__mux2_1
X_2228_ d5.fll_core.strobe d5.mux01.out\[8\] _0254_ vss vss vdd vdd d2.t_load\[66\]
+ sky130_fd_sc_hd__dfrtp_1
X_2159_ clknet_4_2_0_clk_in _0422_ _0185_ vss vss vdd vdd d2.t_load\[67\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1530_ _0631_ d2.r_reg\[35\] _0618_ vss vss vdd vdd _0632_ sky130_fd_sc_hd__mux2_1
X_1461_ d2.r_reg\[57\] d2.t_load\[56\] _0564_ vss vss vdd vdd _0584_ sky130_fd_sc_hd__mux2_1
X_1392_ _0536_ d2.r_reg\[78\] _0530_ vss vss vdd vdd _0537_ sky130_fd_sc_hd__mux2_1
X_2013_ clknet_4_15_0_clk_in _0277_ _0042_ vss vss vdd vdd d2.r_reg\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_309 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1728_ _0752_ vss vss vdd vdd _0022_ sky130_fd_sc_hd__inv_2
XTAP_493 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ _0716_ vss vss vdd vdd d5.mux01.out\[5\] sky130_fd_sc_hd__clkbuf_1
XFILLER_66_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xclkbuf_4_14_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_14_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_37_69 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_26_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_57 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_316 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_254 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_57_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_290 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1513_ d2.r_reg\[41\] d2.t_load\[40\] _0608_ vss vss vdd vdd _0620_ sky130_fd_sc_hd__mux2_1
X_1444_ _0572_ vss vss vdd vdd _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_180 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1375_ d2.r_reg\[84\] net33 _0520_ vss vss vdd vdd _0525_ sky130_fd_sc_hd__mux2_1
XFILLER_55_305 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_290 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_382 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_49_198 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1091_ _0882_ vss vss vdd vdd _0461_ sky130_fd_sc_hd__clkbuf_1
X_1160_ _0927_ vss vss vdd vdd _0437_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_385 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1993_ clknet_4_4_0_clk_in _0257_ _0022_ vss vss vdd vdd d2.r_reg\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_55_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1427_ _0560_ d2.r_reg\[67\] _0552_ vss vss vdd vdd _0561_ sky130_fd_sc_hd__mux2_1
X_1358_ _0513_ vss vss vdd vdd _0345_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_18_49 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1289_ _0472_ vss vss vdd vdd _0376_ sky130_fd_sc_hd__clkbuf_1
XFILLER_34_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_11_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_69 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_105 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_46_157 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_330 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_253 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2192_ clknet_1_1__leaf_ref_in _0454_ _0218_ vss vss vdd vdd d5.fll_core.tmp\[2\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_37_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1212_ _0954_ d2.r_reg\[57\] _0945_ vss vss vdd vdd _0955_ sky130_fd_sc_hd__mux2_1
X_1074_ d5.fll_core.counter2.count\[7\] vss vss vdd vdd _0868_ sky130_fd_sc_hd__inv_2
X_1143_ _0918_ vss vss vdd vdd _0445_ sky130_fd_sc_hd__clkbuf_1
X_1976_ _0779_ vss vss vdd vdd _0240_ sky130_fd_sc_hd__inv_2
XFILLER_29_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_28_113 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xclkbuf_4_2_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_2_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_61_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_45_69 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_374 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_341 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_10_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_19_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_59_293 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_116 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1761_ _0755_ vss vss vdd vdd _0052_ sky130_fd_sc_hd__inv_2
XFILLER_42_171 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1830_ _0762_ vss vss vdd vdd _0114_ sky130_fd_sc_hd__inv_2
XFILLER_15_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1692_ _0732_ _0733_ vss vss vdd vdd _0004_ sky130_fd_sc_hd__nor2_1
XFILLER_65_230 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1126_ _0909_ vss vss vdd vdd _0453_ sky130_fd_sc_hd__clkbuf_1
X_2175_ clknet_4_0_0_clk_in _0438_ _0201_ vss vss vdd vdd net33 sky130_fd_sc_hd__dfrtp_1
X_1057_ d2.t_load\[19\] _0780_ _0782_ d2.t_load\[18\] vss vss vdd vdd _0851_ sky130_fd_sc_hd__o22a_1
XFILLER_15_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_344 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_21_355 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1959_ _0777_ vss vss vdd vdd _0225_ sky130_fd_sc_hd__inv_2
XFILLER_31_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
Xoutput16 net16 vss vss vdd vdd lock sky130_fd_sc_hd__clkbuf_1
Xoutput27 net27 vss vss vdd vdd vbias1[6] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xoutput38 net38 vss vss vdd vdd vbias3[1] sky130_fd_sc_hd__clkbuf_1
XPHY_100 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_133 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_122 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_111 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_12_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_62_277 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_2 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_15_160 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_15_193 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1744_ _0753_ vss vss vdd vdd _0037_ sky130_fd_sc_hd__inv_2
XFILLER_30_152 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_30_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_7_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1813_ _0760_ vss vss vdd vdd _0099_ sky130_fd_sc_hd__inv_2
X_1675_ _0724_ vss vss vdd vdd net11 sky130_fd_sc_hd__clkbuf_1
X_2089_ clknet_1_1__leaf_ref_in _0353_ vss vss vdd vdd d5.fll_core.corner_tmp\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_1109_ _0896_ vss vss vdd vdd _0457_ sky130_fd_sc_hd__clkbuf_1
X_2227_ d5.fll_core.strobe d5.mux01.out\[7\] _0253_ vss vss vdd vdd d2.t_load\[65\]
+ sky130_fd_sc_hd__dfrtp_1
X_2158_ clknet_4_2_0_clk_in _0421_ _0184_ vss vss vdd vdd d2.t_load\[66\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_49 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_42_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_329 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_44_266 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_16_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_130 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_152 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_12_163 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1460_ _0583_ vss vss vdd vdd _0313_ sky130_fd_sc_hd__clkbuf_1
X_1391_ d2.r_reg\[79\] net28 _0520_ vss vss vdd vdd _0536_ sky130_fd_sc_hd__mux2_1
X_2012_ clknet_4_14_0_clk_in _0276_ _0041_ vss vss vdd vdd d2.r_reg\[20\] sky130_fd_sc_hd__dfrtp_1
X_1658_ d5.fll_core.tmp\[5\] d2.t_load\[52\] _0954_ vss vss vdd vdd _0716_ sky130_fd_sc_hd__mux2_1
XFILLER_12_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1727_ _0752_ vss vss vdd vdd _0021_ sky130_fd_sc_hd__inv_2
XFILLER_58_358 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XTAP_494 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ d2.r_reg\[17\] d2.t_load\[16\] _0652_ vss vss vdd vdd _0672_ sky130_fd_sc_hd__mux2_1
XTAP_472 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_41_225 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_26_233 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_64_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1512_ _0619_ vss vss vdd vdd _0297_ sky130_fd_sc_hd__clkbuf_1
X_1443_ _0571_ d2.r_reg\[62\] _0552_ vss vss vdd vdd _0572_ sky130_fd_sc_hd__mux2_1
X_1374_ _0524_ vss vss vdd vdd _0340_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_192 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_4_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_225 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_23_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_58_188 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_280 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_291 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_50 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_49_133 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_64_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_350 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1090_ d5.fll_core.tmp\[9\] _0837_ _0881_ vss vss vdd vdd _0882_ sky130_fd_sc_hd__mux2_1
XFILLER_9_262 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1992_ clknet_4_4_0_clk_in _0256_ _0021_ vss vss vdd vdd net17 sky130_fd_sc_hd__dfrtp_1
X_1288_ d2.t_load\[21\] d2.r_reg\[21\] _0467_ vss vss vdd vdd _0472_ sky130_fd_sc_hd__mux2_1
X_1426_ d2.r_reg\[68\] d2.t_load\[67\] _0542_ vss vss vdd vdd _0560_ sky130_fd_sc_hd__mux2_1
XFILLER_28_317 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1357_ _0512_ d2.r_reg\[89\] _0508_ vss vss vdd vdd _0513_ sky130_fd_sc_hd__mux2_1
XFILLER_55_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_36_383 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_34_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_50_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_34_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_191 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_386 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_24_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2191_ clknet_1_1__leaf_ref_in _0453_ _0217_ vss vss vdd vdd d5.fll_core.tmp\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_37_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1211_ d2.t_load\[57\] vss vss vdd vdd _0954_ sky130_fd_sc_hd__clkbuf_4
XFILLER_1_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1142_ net40 d2.r_reg\[90\] _0912_ vss vss vdd vdd _0918_ sky130_fd_sc_hd__mux2_1
XFILLER_45_191 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_37_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_375 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1073_ d5.fll_core.counter2.count\[1\] vss vss vdd vdd _0867_ sky130_fd_sc_hd__inv_2
XFILLER_60_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_20_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1975_ _0779_ vss vss vdd vdd _0239_ sky130_fd_sc_hd__inv_2
XFILLER_29_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1409_ _0548_ vss vss vdd vdd _0329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_45_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_320 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_150 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_3_268 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_59_272 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_19_147 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_180 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1760_ _0755_ vss vss vdd vdd _0051_ sky130_fd_sc_hd__inv_2
X_1691_ d5.fll_core.counter1.count\[3\] _0730_ vss vss vdd vdd _0733_ sky130_fd_sc_hd__nor2_1
XFILLER_30_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_323 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1125_ d5.fll_core.tmp\[1\] _0908_ _0881_ vss vss vdd vdd _0909_ sky130_fd_sc_hd__mux2_1
XFILLER_25_106 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2174_ clknet_4_0_0_clk_in _0437_ _0200_ vss vss vdd vdd net32 sky130_fd_sc_hd__dfrtp_1
X_1056_ _0847_ _0848_ _0849_ vss vss vdd vdd _0850_ sky130_fd_sc_hd__a21o_1
XFILLER_40_109 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_21_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_367 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1889_ _0771_ vss vss vdd vdd _0161_ sky130_fd_sc_hd__inv_2
Xoutput28 net28 vss vss vdd vdd vbias1[7] sky130_fd_sc_hd__clkbuf_1
X_1958_ _0777_ vss vss vdd vdd _0224_ sky130_fd_sc_hd__inv_2
XFILLER_31_39 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xoutput17 net17 vss vss vdd vdd s_out sky130_fd_sc_hd__clkbuf_1
Xoutput39 net39 vss vss vdd vdd vbias3[2] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_238 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_123 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_56_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XPHY_112 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_101 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_245 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XPHY_3 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1674_ d2.t_load\[61\] d2.t_load\[37\] d2.t_load\[44\] vss vss vdd vdd _0724_ sky130_fd_sc_hd__mux2_1
X_1743_ _0753_ vss vss vdd vdd _0036_ sky130_fd_sc_hd__inv_2
XFILLER_30_197 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1812_ _0760_ vss vss vdd vdd _0098_ sky130_fd_sc_hd__inv_2
XTAP_610 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2226_ d5.fll_core.strobe d5.mux01.out\[6\] _0252_ vss vss vdd vdd d2.t_load\[64\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2088_ clknet_1_1__leaf_ref_in _0352_ vss vss vdd vdd d5.fll_core.corner_tmp\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_2157_ clknet_4_8_0_clk_in _0420_ _0183_ vss vss vdd vdd d2.t_load\[65\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1108_ d5.fll_core.tmp\[5\] _0895_ _0881_ vss vss vdd vdd _0896_ sky130_fd_sc_hd__mux2_1
X_1039_ d5.fll_core.tmp\[8\] _0817_ vss vss vdd vdd _0834_ sky130_fd_sc_hd__and2_1
XFILLER_42_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_223 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_286 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_29_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_72 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_175 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_4_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1390_ _0535_ vss vss vdd vdd _0335_ sky130_fd_sc_hd__clkbuf_1
X_2011_ clknet_4_14_0_clk_in _0275_ _0040_ vss vss vdd vdd d2.r_reg\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1588_ _0671_ vss vss vdd vdd _0273_ sky130_fd_sc_hd__clkbuf_1
X_1657_ _0715_ vss vss vdd vdd d5.mux01.out\[4\] sky130_fd_sc_hd__clkbuf_1
X_1726_ _0751_ vss vss vdd vdd _0752_ sky130_fd_sc_hd__buf_4
X_2209_ clknet_1_1__leaf_vco_in _0010_ _0235_ vss vss vdd vdd d5.fll_core.counter1.count\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_495 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_26_212 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_138 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_49_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_57_381 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_17_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_32_226 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1511_ _0617_ d2.r_reg\[41\] _0618_ vss vss vdd vdd _0619_ sky130_fd_sc_hd__mux2_1
X_1442_ d2.r_reg\[63\] d2.t_load\[62\] _0564_ vss vss vdd vdd _0571_ sky130_fd_sc_hd__mux2_1
X_1373_ _0523_ d2.r_reg\[84\] _0508_ vss vss vdd vdd _0524_ sky130_fd_sc_hd__mux2_1
XFILLER_4_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_23_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_31_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1709_ d5.fll_core.counter2.count\[3\] _0740_ vss vss vdd vdd _0742_ sky130_fd_sc_hd__and2_1
XFILLER_54_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_46_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_270 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_292 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_62 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_163 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_45_384 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_45_362 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_62_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1991_ _0751_ vss vss vdd vdd _0255_ sky130_fd_sc_hd__inv_2
XFILLER_9_241 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_13_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1425_ _0559_ vss vss vdd vdd _0324_ sky130_fd_sc_hd__clkbuf_1
X_1287_ _0471_ vss vss vdd vdd _0377_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_159 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_55_126 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1356_ d2.r_reg\[90\] net39 _0498_ vss vss vdd vdd _0512_ sky130_fd_sc_hd__mux2_1
XFILLER_18_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_343 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_61_129 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_170 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_42_376 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_42_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_233 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_251 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_273 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_91 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2190_ clknet_1_1__leaf_ref_in _0452_ _0216_ vss vss vdd vdd d5.fll_core.tmp\[0\]
+ sky130_fd_sc_hd__dfstp_2
XFILLER_37_126 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1072_ d2.t_load\[8\] vss vss vdd vdd _0866_ sky130_fd_sc_hd__inv_2
X_1210_ _0953_ vss vss vdd vdd _0413_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1141_ _0917_ vss vss vdd vdd _0446_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_340 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_33_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_33_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1974_ _0779_ vss vss vdd vdd _0238_ sky130_fd_sc_hd__inv_2
XFILLER_29_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1408_ _0547_ d2.r_reg\[73\] _0530_ vss vss vdd vdd _0548_ sky130_fd_sc_hd__mux2_1
XFILLER_45_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_36_181 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1339_ _0500_ vss vss vdd vdd _0351_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_3_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_85 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_19_159 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1690_ d5.fll_core.counter1.count\[3\] _0730_ vss vss vdd vdd _0732_ sky130_fd_sc_hd__and2_1
XFILLER_30_357 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_25_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_243 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_65_210 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1055_ d2.t_load\[17\] _0787_ _0782_ d2.t_load\[18\] vss vss vdd vdd _0849_ sky130_fd_sc_hd__a22o_1
X_1124_ _0906_ _0907_ vss vss vdd vdd _0908_ sky130_fd_sc_hd__nor2_1
X_2173_ clknet_4_1_0_clk_in _0436_ _0199_ vss vss vdd vdd net31 sky130_fd_sc_hd__dfrtp_1
X_1957_ _0777_ vss vss vdd vdd _0223_ sky130_fd_sc_hd__inv_2
XFILLER_33_162 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_21_379 vss vss vdd vdd sky130_ef_sc_hd__decap_12
Xoutput18 net18 vss vss vdd vdd slope_ctrl[0] sky130_fd_sc_hd__clkbuf_1
X_1888_ _0757_ vss vss vdd vdd _0771_ sky130_fd_sc_hd__buf_4
Xoutput29 net29 vss vss vdd vdd vbias2[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_0_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_56_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_124 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_113 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_102 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_184 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_335 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_8_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_276 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_30_110 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_4 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1811_ _0760_ vss vss vdd vdd _0097_ sky130_fd_sc_hd__inv_2
XTAP_600 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1673_ _0723_ vss vss vdd vdd net10 sky130_fd_sc_hd__clkbuf_1
X_1742_ _0753_ vss vss vdd vdd _0035_ sky130_fd_sc_hd__inv_2
XFILLER_11_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_611 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2225_ d5.fll_core.strobe d5.mux01.out\[5\] _0251_ vss vss vdd vdd d2.t_load\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_213 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2156_ clknet_4_8_0_clk_in _0419_ _0182_ vss vss vdd vdd d2.t_load\[64\] sky130_fd_sc_hd__dfrtp_1
X_1038_ _0825_ _0826_ _0830_ _0832_ _0817_ vss vss vdd vdd _0833_ sky130_fd_sc_hd__a32o_1
X_1107_ _0828_ _0894_ vss vss vdd vdd _0895_ sky130_fd_sc_hd__xnor2_1
XFILLER_26_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2087_ clknet_4_5_0_clk_in _0351_ _0116_ vss vss vdd vdd d2.r_reg\[95\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_290 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_187 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_32_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_4_331 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_80 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2010_ clknet_4_13_0_clk_in _0274_ _0039_ vss vss vdd vdd d2.r_reg\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_227 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_35_246 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1725_ _0750_ vss vss vdd vdd _0751_ sky130_fd_sc_hd__buf_4
X_1587_ _0670_ d2.r_reg\[17\] _0662_ vss vss vdd vdd _0671_ sky130_fd_sc_hd__mux2_1
XTAP_441 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1656_ d5.fll_core.tmp\[4\] d2.t_load\[51\] _0954_ vss vss vdd vdd _0715_ sky130_fd_sc_hd__mux2_1
X_2208_ clknet_1_1__leaf_vco_in _0009_ _0234_ vss vss vdd vdd d5.fll_core.counter1.count\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_496 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2139_ clknet_4_12_0_clk_in _0402_ _0165_ vss vss vdd vdd d2.t_load\[47\] sky130_fd_sc_hd__dfrtp_1
XTAP_474 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_26_246 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_41_216 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_34_290 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_50 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1510_ _0478_ vss vss vdd vdd _0618_ sky130_fd_sc_hd__clkbuf_4
X_1441_ _0570_ vss vss vdd vdd _0319_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_161 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1372_ d2.r_reg\[85\] net34 _0520_ vss vss vdd vdd _0523_ sky130_fd_sc_hd__mux2_1
X_1708_ _0740_ _0741_ vss vss vdd vdd _0013_ sky130_fd_sc_hd__nor2_1
XFILLER_48_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1639_ d2.r_reg\[1\] d2.t_load\[0\] _0497_ vss vss vdd vdd _0706_ sky130_fd_sc_hd__mux2_1
XTAP_260 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_22_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_64_127 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_113 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_38_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_60_377 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1990_ _0751_ vss vss vdd vdd _0254_ sky130_fd_sc_hd__inv_2
XFILLER_13_260 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_55_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1424_ _0558_ d2.r_reg\[68\] _0552_ vss vss vdd vdd _0559_ sky130_fd_sc_hd__mux2_1
X_1355_ _0511_ vss vss vdd vdd _0346_ sky130_fd_sc_hd__clkbuf_1
X_1286_ d2.t_load\[22\] d2.r_reg\[22\] _0467_ vss vss vdd vdd _0471_ sky130_fd_sc_hd__mux2_1
XFILLER_48_190 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_374 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_36_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f_vco_in clknet_0_vco_in vss vss vdd vdd clknet_1_1__leaf_vco_in sky130_fd_sc_hd__clkbuf_16
XFILLER_51_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_34_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_119 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_39_190 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_245 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_37_138 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1071_ d5.fll_core.counter2.count\[6\] vss vss vdd vdd _0865_ sky130_fd_sc_hd__inv_2
XFILLER_1_44 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1140_ net41 d2.r_reg\[91\] _0912_ vss vss vdd vdd _0917_ sky130_fd_sc_hd__mux2_1
XFILLER_18_352 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_163 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_366 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_33_344 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1973_ _0779_ vss vss vdd vdd _0237_ sky130_fd_sc_hd__inv_2
XFILLER_28_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1338_ _0499_ d2.r_reg\[95\] _0490_ vss vss vdd vdd _0500_ sky130_fd_sc_hd__mux2_1
X_1407_ d2.r_reg\[74\] net23 _0542_ vss vss vdd vdd _0547_ sky130_fd_sc_hd__mux2_1
X_1269_ d2.t_load\[30\] d2.r_reg\[30\] _0979_ vss vss vdd vdd _0462_ sky130_fd_sc_hd__mux2_1
XFILLER_45_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_388 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_174 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_10_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_97 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_42_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_30_347 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_15_322 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_292 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2172_ clknet_4_1_0_clk_in _0435_ _0198_ vss vss vdd vdd net30 sky130_fd_sc_hd__dfrtp_1
XFILLER_18_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1054_ d2.t_load\[17\] _0787_ _0788_ d2.t_load\[16\] vss vss vdd vdd _0848_ sky130_fd_sc_hd__o22a_1
X_1123_ _0822_ _0821_ d5.fll_core.tmp\[0\] vss vss vdd vdd _0907_ sky130_fd_sc_hd__a21oi_1
XFILLER_18_193 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1887_ _0770_ vss vss vdd vdd _0160_ sky130_fd_sc_hd__inv_2
X_1956_ _0777_ vss vss vdd vdd _0222_ sky130_fd_sc_hd__inv_2
Xoutput19 net19 vss vss vdd vdd slope_ctrl[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_125 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_114 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_103 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_20_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_74 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_47_266 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XPHY_5 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1741_ _0753_ vss vss vdd vdd _0034_ sky130_fd_sc_hd__inv_2
XFILLER_30_188 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1810_ _0760_ vss vss vdd vdd _0096_ sky130_fd_sc_hd__inv_2
XTAP_612 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_601 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1672_ d2.t_load\[60\] d2.t_load\[36\] d2.t_load\[44\] vss vss vdd vdd _0723_ sky130_fd_sc_hd__mux2_1
X_1106_ _0825_ _0827_ _0893_ vss vss vdd vdd _0894_ sky130_fd_sc_hd__a21oi_1
X_2155_ clknet_4_8_0_clk_in _0418_ _0181_ vss vss vdd vdd d2.t_load\[63\] sky130_fd_sc_hd__dfrtp_1
X_2224_ d5.fll_core.strobe d5.mux01.out\[4\] _0250_ vss vss vdd vdd d2.t_load\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_38_288 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_53_247 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_53_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1037_ d5.fll_core.tmp\[7\] d5.fll_core.tmp\[6\] _0831_ vss vss vdd vdd _0832_ sky130_fd_sc_hd__or3_1
X_2086_ clknet_4_5_0_clk_in _0350_ _0115_ vss vss vdd vdd d2.r_reg\[94\] sky130_fd_sc_hd__dfrtp_1
X_1939_ _0775_ vss vss vdd vdd _0207_ sky130_fd_sc_hd__inv_2
XFILLER_29_200 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_44_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_299 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_29_266 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_159 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_16_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_16_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_4_343 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_35_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1724_ net3 vss vss vdd vdd _0750_ sky130_fd_sc_hd__buf_4
XFILLER_7_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_58_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_475 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1586_ d2.r_reg\[18\] d2.t_load\[17\] _0652_ vss vss vdd vdd _0670_ sky130_fd_sc_hd__mux2_1
XTAP_464 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1655_ _0714_ vss vss vdd vdd d5.mux01.out\[3\] sky130_fd_sc_hd__clkbuf_1
XTAP_442 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ clknet_1_1__leaf_vco_in _0008_ _0233_ vss vss vdd vdd d5.fll_core.counter1.count\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_2138_ clknet_4_14_0_clk_in _0401_ _0164_ vss vss vdd vdd d2.t_load\[46\] sky130_fd_sc_hd__dfrtp_1
XTAP_497 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2069_ clknet_4_2_0_clk_in _0333_ _0098_ vss vss vdd vdd d2.r_reg\[77\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_34_280 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_64_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_57_350 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_328 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_1_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_17_225 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_40_283 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1440_ _0569_ d2.r_reg\[63\] _0552_ vss vss vdd vdd _0570_ sky130_fd_sc_hd__mux2_1
X_1371_ _0522_ vss vss vdd vdd _0341_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_309 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_350 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_31_261 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_291 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1638_ _0705_ vss vss vdd vdd _0257_ sky130_fd_sc_hd__clkbuf_1
X_1707_ d5.fll_core.counter2.count\[0\] d5.fll_core.counter2.count\[1\] d5.fll_core.counter2.count\[2\]
+ vss vss vdd vdd _0741_ sky130_fd_sc_hd__a21oi_1
X_1569_ _0658_ vss vss vdd vdd _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_147 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_58_136 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_250 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_294 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xclkbuf_4_5_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_5_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_13_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_158 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_125 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_45_342 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_60_356 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_54_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_20_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1285_ _0470_ vss vss vdd vdd _0378_ sky130_fd_sc_hd__clkbuf_1
XFILLER_48_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1423_ d2.r_reg\[69\] net18 _0542_ vss vss vdd vdd _0558_ sky130_fd_sc_hd__mux2_1
XFILLER_28_309 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1354_ _0510_ d2.r_reg\[90\] _0508_ vss vss vdd vdd _0511_ sky130_fd_sc_hd__mux2_1
XFILLER_51_389 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_50_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_342 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_24_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_24_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_71 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_81 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_109 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_161 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1070_ _0861_ d5.fll_core.counter2.count\[0\] _0862_ d2.t_load\[9\] _0863_ vss vss
+ vdd vdd _0864_ sky130_fd_sc_hd__o221a_1
XFILLER_18_320 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1972_ _0779_ vss vss vdd vdd _0236_ sky130_fd_sc_hd__inv_2
X_1268_ _0984_ vss vss vdd vdd _0386_ sky130_fd_sc_hd__clkbuf_1
X_1337_ net4 d2.t_load\[95\] _0498_ vss vss vdd vdd _0499_ sky130_fd_sc_hd__mux2_1
X_1406_ _0546_ vss vss vdd vdd _0330_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1199_ d2.t_load\[63\] d2.r_reg\[63\] _0945_ vss vss vdd vdd _0948_ sky130_fd_sc_hd__mux2_1
XFILLER_36_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_356 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_249 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_15_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_51_94 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_65_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1122_ d5.fll_core.tmp\[0\] _0822_ _0821_ vss vss vdd vdd _0906_ sky130_fd_sc_hd__and3_1
X_2171_ clknet_4_1_0_clk_in _0434_ _0197_ vss vss vdd vdd net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_65_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1053_ _0844_ _0845_ _0846_ vss vss vdd vdd _0847_ sky130_fd_sc_hd__a21o_1
XFILLER_33_142 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_161 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1886_ _0770_ vss vss vdd vdd _0159_ sky130_fd_sc_hd__inv_2
X_1955_ _0777_ vss vss vdd vdd _0221_ sky130_fd_sc_hd__inv_2
XPHY_126 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_115 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_104 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_348 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_47_212 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_6 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1671_ _0722_ vss vss vdd vdd net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_62_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1740_ _0753_ vss vss vdd vdd _0033_ sky130_fd_sc_hd__inv_2
XFILLER_30_178 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_30_134 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_7_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_15_197 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_613 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_602 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2223_ d5.fll_core.strobe d5.mux01.out\[3\] _0249_ vss vss vdd vdd d2.t_load\[61\]
+ sky130_fd_sc_hd__dfrtp_1
X_1105_ d5.fll_core.tmp\[4\] _0817_ vss vss vdd vdd _0893_ sky130_fd_sc_hd__and2_1
X_2154_ clknet_4_8_0_clk_in _0417_ _0180_ vss vss vdd vdd d2.t_load\[62\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_234 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_38_201 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2085_ clknet_4_5_0_clk_in _0349_ _0114_ vss vss vdd vdd d2.r_reg\[93\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1036_ d5.fll_core.tmp\[5\] d5.fll_core.tmp\[4\] vss vss vdd vdd _0831_ sky130_fd_sc_hd__or2_1
XFILLER_21_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1869_ _0769_ vss vss vdd vdd _0143_ sky130_fd_sc_hd__inv_2
X_1938_ _0775_ vss vss vdd vdd _0206_ sky130_fd_sc_hd__inv_2
XFILLER_29_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_53 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_85 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_32_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_4_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_8_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_134 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_4_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_4_355 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_57_93 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_43_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1654_ d5.fll_core.tmp\[3\] d2.t_load\[50\] _0954_ vss vss vdd vdd _0714_ sky130_fd_sc_hd__mux2_1
X_1723_ _0862_ _0748_ vss vss vdd vdd _0020_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2206_ clknet_1_1__leaf_vco_in _0007_ _0232_ vss vss vdd vdd d5.fll_core.counter1.count\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_58_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_498 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1585_ _0669_ vss vss vdd vdd _0274_ sky130_fd_sc_hd__clkbuf_1
XTAP_487 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1019_ _0813_ _0785_ _0795_ _0801_ vss vss vdd vdd _0814_ sky130_fd_sc_hd__and4b_1
X_2137_ clknet_4_11_0_clk_in _0400_ _0163_ vss vss vdd vdd d2.t_load\[45\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_270 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2068_ clknet_4_3_0_clk_in _0332_ _0097_ vss vss vdd vdd d2.r_reg\[76\] sky130_fd_sc_hd__dfrtp_1
XFILLER_1_303 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_43_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_248 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_4_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_4_152 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1370_ _0521_ d2.r_reg\[85\] _0508_ vss vss vdd vdd _0522_ sky130_fd_sc_hd__mux2_1
X_1637_ _0704_ d2.r_reg\[1\] _0911_ vss vss vdd vdd _0705_ sky130_fd_sc_hd__mux2_1
X_1706_ d5.fll_core.counter2.count\[0\] d5.fll_core.counter2.count\[1\] d5.fll_core.counter2.count\[2\]
+ vss vss vdd vdd _0740_ sky130_fd_sc_hd__and3_1
XFILLER_66_181 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1568_ _0657_ d2.r_reg\[23\] _0640_ vss vss vdd vdd _0658_ sky130_fd_sc_hd__mux2_1
X_1499_ _0610_ vss vss vdd vdd _0301_ sky130_fd_sc_hd__clkbuf_1
XFILLER_48_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_240 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_13_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_104 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_8_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_240 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1422_ _0557_ vss vss vdd vdd _0325_ sky130_fd_sc_hd__clkbuf_1
X_1284_ d2.t_load\[23\] d2.r_reg\[23\] _0467_ vss vss vdd vdd _0470_ sky130_fd_sc_hd__mux2_1
XFILLER_48_170 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1353_ d2.r_reg\[91\] net40 _0498_ vss vss vdd vdd _0510_ sky130_fd_sc_hd__mux2_1
XFILLER_63_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_0999_ d2.t_load\[25\] _0790_ _0793_ d2.t_load\[24\] vss vss vdd vdd _0794_ sky130_fd_sc_hd__o22a_1
XFILLER_59_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_387 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_42_346 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_53 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_40_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_18_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_187 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_176 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_60_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1971_ d5.fll_core.counter_reset vss vss vdd vdd _0779_ sky130_fd_sc_hd__buf_4
X_1405_ _0545_ d2.r_reg\[74\] _0530_ vss vss vdd vdd _0546_ sky130_fd_sc_hd__mux2_1
X_1267_ d2.t_load\[31\] d2.r_reg\[31\] _0979_ vss vss vdd vdd _0984_ sky130_fd_sc_hd__mux2_1
X_1198_ _0947_ vss vss vdd vdd _0419_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_162 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_107 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xinput1 load vss vss vdd vdd net1 sky130_fd_sc_hd__dlymetal6s2s_1
X_1336_ _0497_ vss vss vdd vdd _0498_ sky130_fd_sc_hd__clkbuf_4
XFILLER_51_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_390 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_3_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_10_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_42_154 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_27_184 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_162 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_51_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_165 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_30_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
Xclkbuf_0_vco_in vco_in vss vss vdd vdd clknet_0_vco_in sky130_fd_sc_hd__clkbuf_16
XFILLER_2_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_65_268 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1052_ d2.t_load\[16\] _0788_ _0790_ d2.t_load\[15\] vss vss vdd vdd _0846_ sky130_fd_sc_hd__a22o_1
X_1121_ _0905_ vss vss vdd vdd _0454_ sky130_fd_sc_hd__clkbuf_1
X_2170_ clknet_4_0_0_clk_in _0433_ _0196_ vss vss vdd vdd net28 sky130_fd_sc_hd__dfrtp_2
X_1954_ _0750_ vss vss vdd vdd _0777_ sky130_fd_sc_hd__buf_4
XFILLER_33_198 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_173 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_305 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1885_ _0770_ vss vss vdd vdd _0158_ sky130_fd_sc_hd__inv_2
XFILLER_56_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_0_209 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_116 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_105 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1319_ _0488_ vss vss vdd vdd _0362_ sky130_fd_sc_hd__clkbuf_1
XPHY_127 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_8_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_12_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_21_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_47_202 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_7 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_15_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1670_ d2.t_load\[59\] d2.t_load\[35\] d2.t_load\[44\] vss vss vdd vdd _0722_ sky130_fd_sc_hd__mux2_1
XFILLER_7_89 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_7_342 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_614 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_603 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2222_ d5.fll_core.strobe d5.mux01.out\[2\] _0248_ vss vss vdd vdd d2.t_load\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1035_ _0827_ _0828_ _0829_ vss vss vdd vdd _0830_ sky130_fd_sc_hd__and3_1
X_2153_ clknet_4_9_0_clk_in _0416_ _0179_ vss vss vdd vdd d2.t_load\[61\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_268 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_213 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1104_ _0892_ vss vss vdd vdd _0458_ sky130_fd_sc_hd__clkbuf_1
X_2084_ clknet_4_5_0_clk_in _0348_ _0113_ vss vss vdd vdd d2.r_reg\[92\] sky130_fd_sc_hd__dfrtp_1
X_1937_ _0775_ vss vss vdd vdd _0205_ sky130_fd_sc_hd__inv_2
XFILLER_21_102 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1868_ _0769_ vss vss vdd vdd _0142_ sky130_fd_sc_hd__inv_2
X_1799_ _0759_ vss vss vdd vdd _0086_ sky130_fd_sc_hd__inv_2
XFILLER_52_282 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_52_271 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_52_260 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_249 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_32_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_64 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_53 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_4_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1584_ _0668_ d2.r_reg\[18\] _0662_ vss vss vdd vdd _0669_ sky130_fd_sc_hd__mux2_1
X_1653_ _0713_ vss vss vdd vdd d5.mux01.out\[2\] sky130_fd_sc_hd__clkbuf_1
XTAP_400 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1722_ _0748_ _0749_ vss vss vdd vdd _0019_ sky130_fd_sc_hd__nor2_1
X_2205_ clknet_1_1__leaf_vco_in _0006_ _0231_ vss vss vdd vdd d5.fll_core.counter1.count\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_499 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_385 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1018_ _0811_ d5.fll_core.counter1.count\[0\] _0812_ _0804_ vss vss vdd vdd _0813_
+ sky130_fd_sc_hd__a211o_1
X_2136_ clknet_4_11_0_clk_in _0399_ _0162_ vss vss vdd vdd d2.t_load\[44\] sky130_fd_sc_hd__dfrtp_4
X_2067_ clknet_4_2_0_clk_in _0331_ _0096_ vss vss vdd vdd d2.r_reg\[75\] sky130_fd_sc_hd__dfrtp_1
XFILLER_1_337 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_315 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_17_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_0_370 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_63_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_48_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_274 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1705_ d5.fll_core.counter2.count\[0\] d5.fll_core.counter2.count\[1\] vss vss vdd
+ vdd _0012_ sky130_fd_sc_hd__xor2_1
X_1567_ d2.r_reg\[24\] d2.t_load\[23\] _0652_ vss vss vdd vdd _0657_ sky130_fd_sc_hd__mux2_1
XTAP_230 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1636_ d2.r_reg\[2\] d2.t_load\[1\] _0497_ vss vss vdd vdd _0704_ sky130_fd_sc_hd__mux2_1
XFILLER_64_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2119_ clknet_4_14_0_clk_in _0382_ _0145_ vss vss vdd vdd d2.t_load\[27\] sky130_fd_sc_hd__dfrtp_1
X_1498_ _0609_ d2.r_reg\[45\] _0596_ vss vss vdd vdd _0610_ sky130_fd_sc_hd__mux2_1
XTAP_252 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_241 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_44 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_13_99 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_49_138 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_60_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_57_193 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_57_160 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_45_377 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_355 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_300 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_38_96 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_38_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1421_ _0556_ d2.r_reg\[69\] _0552_ vss vss vdd vdd _0557_ sky130_fd_sc_hd__mux2_1
X_1283_ _0469_ vss vss vdd vdd _0379_ sky130_fd_sc_hd__clkbuf_1
XFILLER_48_182 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1352_ _0509_ vss vss vdd vdd _0347_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_369 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0998_ d5.fll_core.counter1.count\[4\] vss vss vdd vdd _0793_ sky130_fd_sc_hd__inv_2
X_1619_ _0692_ d2.r_reg\[7\] _0684_ vss vss vdd vdd _0693_ sky130_fd_sc_hd__mux2_1
XFILLER_54_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_358 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_20 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_10_233 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_266 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_299 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_69 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_18_333 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1970_ _0778_ vss vss vdd vdd _0235_ sky130_fd_sc_hd__inv_2
XFILLER_33_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_303 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_18_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_53_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_281 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_270 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1335_ net2 vss vss vdd vdd _0497_ sky130_fd_sc_hd__clkbuf_4
X_1404_ d2.r_reg\[75\] net24 _0542_ vss vss vdd vdd _0545_ sky130_fd_sc_hd__mux2_1
X_1266_ _0983_ vss vss vdd vdd _0387_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_100 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1197_ d2.t_load\[64\] d2.r_reg\[64\] _0945_ vss vss vdd vdd _0947_ sky130_fd_sc_hd__mux2_1
XFILLER_36_152 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_314 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xinput2 read vss vss vdd vdd net2 sky130_fd_sc_hd__clkbuf_4
XFILLER_51_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_119 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_23_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_2_240 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_65_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1051_ d2.t_load\[15\] _0790_ _0793_ d2.t_load\[14\] vss vss vdd vdd _0845_ sky130_fd_sc_hd__o22a_1
X_1120_ d5.fll_core.tmp\[2\] _0904_ _0881_ vss vss vdd vdd _0905_ sky130_fd_sc_hd__mux2_1
XFILLER_18_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_18_185 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1884_ _0770_ vss vss vdd vdd _0157_ sky130_fd_sc_hd__inv_2
X_1953_ _0776_ vss vss vdd vdd _0220_ sky130_fd_sc_hd__inv_2
XFILLER_33_155 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1318_ d2.t_load\[7\] d2.r_reg\[7\] _0479_ vss vss vdd vdd _0488_ sky130_fd_sc_hd__mux2_1
XPHY_128 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_117 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_106 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1249_ _0974_ vss vss vdd vdd _0395_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_350 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_62_206 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_46_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_96 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XPHY_8 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_7_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_615 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_604 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2221_ d5.fll_core.strobe d5.mux01.out\[1\] _0247_ vss vss vdd vdd d2.t_load\[59\]
+ sky130_fd_sc_hd__dfrtp_1
X_2152_ clknet_4_9_0_clk_in _0415_ _0178_ vss vss vdd vdd d2.t_load\[60\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_53_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_46_280 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1034_ d5.fll_core.tmp\[7\] _0816_ vss vss vdd vdd _0829_ sky130_fd_sc_hd__xnor2_1
X_1103_ d5.fll_core.tmp\[6\] _0891_ _0881_ vss vss vdd vdd _0892_ sky130_fd_sc_hd__mux2_1
X_2083_ clknet_4_5_0_clk_in _0347_ _0112_ vss vss vdd vdd d2.r_reg\[91\] sky130_fd_sc_hd__dfrtp_1
X_1867_ _0769_ vss vss vdd vdd _0141_ sky130_fd_sc_hd__inv_2
X_1936_ _0775_ vss vss vdd vdd _0204_ sky130_fd_sc_hd__inv_2
XFILLER_21_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1798_ _0759_ vss vss vdd vdd _0085_ sky130_fd_sc_hd__inv_2
XFILLER_29_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_52_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_8_107 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_66 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_57_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_261 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_35_206 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1721_ d5.fll_core.counter2.count\[7\] _0746_ d5.fll_core.counter2.count\[8\] vss
+ vss vdd vdd _0749_ sky130_fd_sc_hd__a21oi_1
X_1583_ d2.r_reg\[19\] d2.t_load\[18\] _0652_ vss vss vdd vdd _0668_ sky130_fd_sc_hd__mux2_1
X_1652_ d5.fll_core.tmp\[2\] d2.t_load\[49\] _0954_ vss vss vdd vdd _0713_ sky130_fd_sc_hd__mux2_1
XTAP_423 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2204_ clknet_1_0__leaf_vco_in _0005_ _0230_ vss vss vdd vdd d5.fll_core.counter1.count\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_58_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_489 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2135_ clknet_4_9_0_clk_in _0398_ _0161_ vss vss vdd vdd d2.t_load\[43\] sky130_fd_sc_hd__dfrtp_1
XTAP_456 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1017_ _0802_ _0803_ vss vss vdd vdd _0812_ sky130_fd_sc_hd__nand2_1
XFILLER_41_209 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_34_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2066_ clknet_4_2_0_clk_in _0330_ _0095_ vss vss vdd vdd d2.r_reg\[74\] sky130_fd_sc_hd__dfrtp_1
X_1919_ _0773_ vss vss vdd vdd _0189_ sky130_fd_sc_hd__inv_2
XFILLER_1_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_327 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_57_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_87 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_250 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_43_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_297 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xclkbuf_4_10_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_10_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_0_382 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_367 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_31_231 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_220 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1704_ _0780_ _0738_ vss vss vdd vdd _0010_ sky130_fd_sc_hd__xnor2_1
X_1566_ _0656_ vss vss vdd vdd _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_128 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1497_ d2.r_reg\[46\] d2.t_load\[45\] _0608_ vss vss vdd vdd _0609_ sky130_fd_sc_hd__mux2_1
XTAP_220 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1635_ _0703_ vss vss vdd vdd _0258_ sky130_fd_sc_hd__clkbuf_1
XTAP_264 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2118_ clknet_4_14_0_clk_in _0381_ _0144_ vss vss vdd vdd d2.t_load\[26\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_375 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_331 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_286 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2049_ clknet_4_3_0_clk_in _0313_ _0078_ vss vss vdd vdd d2.r_reg\[57\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_38_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_183 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_54_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_45_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1420_ d2.r_reg\[70\] net19 _0542_ vss vss vdd vdd _0556_ sky130_fd_sc_hd__mux2_1
X_1351_ _0507_ d2.r_reg\[91\] _0508_ vss vss vdd vdd _0509_ sky130_fd_sc_hd__mux2_1
X_1282_ d2.t_load\[24\] d2.r_reg\[24\] _0467_ vss vss vdd vdd _0469_ sky130_fd_sc_hd__mux2_1
XFILLER_63_153 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_51_337 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_51_326 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_315 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0997_ d2.t_load\[26\] _0788_ _0790_ d2.t_load\[25\] _0791_ vss vss vdd vdd _0792_
+ sky130_fd_sc_hd__a221oi_1
X_1618_ d2.r_reg\[8\] d2.t_load\[7\] _0674_ vss vss vdd vdd _0692_ sky130_fd_sc_hd__mux2_1
X_1549_ _0644_ d2.r_reg\[29\] _0640_ vss vss vdd vdd _0645_ sky130_fd_sc_hd__mux2_1
XFILLER_54_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_39_183 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_370 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_245 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_65 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_45_153 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_33_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1265_ d2.t_load\[32\] d2.r_reg\[32\] _0979_ vss vss vdd vdd _0983_ sky130_fd_sc_hd__mux2_1
XFILLER_46_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1334_ _0496_ vss vss vdd vdd _0355_ sky130_fd_sc_hd__clkbuf_1
X_1403_ _0544_ vss vss vdd vdd _0331_ sky130_fd_sc_hd__clkbuf_1
X_1196_ _0946_ vss vss vdd vdd _0420_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_348 vss vss vdd vdd sky130_fd_sc_hd__decap_8
Xinput3 reset vss vss vdd vdd net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_51_156 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_59_289 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_19_77 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_134 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_35_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_337 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_237 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1050_ d2.t_load\[13\] _0838_ _0793_ d2.t_load\[14\] _0843_ vss vss vdd vdd _0844_
+ sky130_fd_sc_hd__a221o_1
XFILLER_18_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1883_ _0770_ vss vss vdd vdd _0156_ sky130_fd_sc_hd__inv_2
X_1952_ _0776_ vss vss vdd vdd _0219_ sky130_fd_sc_hd__inv_2
XFILLER_21_318 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1248_ d2.t_load\[40\] d2.r_reg\[40\] _0968_ vss vss vdd vdd _0974_ sky130_fd_sc_hd__mux2_1
X_1317_ _0487_ vss vss vdd vdd _0363_ sky130_fd_sc_hd__clkbuf_1
XPHY_129 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_118 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_107 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_167 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_156 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1179_ _0937_ vss vss vdd vdd _0428_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_46_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_9 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_62_96 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_62_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_62_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_616 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_605 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_69 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2220_ d5.fll_core.strobe d5.mux01.out\[0\] _0246_ vss vss vdd vdd d2.t_load\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_38_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1102_ _0826_ _0886_ vss vss vdd vdd _0891_ sky130_fd_sc_hd__xor2_1
X_2151_ clknet_4_9_0_clk_in _0414_ _0177_ vss vss vdd vdd d2.t_load\[59\] sky130_fd_sc_hd__dfrtp_1
X_2082_ clknet_4_4_0_clk_in _0346_ _0111_ vss vss vdd vdd d2.r_reg\[90\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_207 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1033_ d5.fll_core.tmp\[5\] _0816_ vss vss vdd vdd _0828_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_126 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1866_ _0757_ vss vss vdd vdd _0769_ sky130_fd_sc_hd__buf_4
X_1797_ _0759_ vss vss vdd vdd _0084_ sky130_fd_sc_hd__inv_2
X_1935_ _0775_ vss vss vdd vdd _0203_ sky130_fd_sc_hd__inv_2
XFILLER_37_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_240 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xclkbuf_4_8_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_8_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_12_104 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_126 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_20_170 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_63 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1651_ _0712_ vss vss vdd vdd d5.mux01.out\[1\] sky130_fd_sc_hd__clkbuf_1
X_1720_ d5.fll_core.counter2.count\[7\] d5.fll_core.counter2.count\[8\] _0746_ vss
+ vss vdd vdd _0748_ sky130_fd_sc_hd__and3_1
XFILLER_11_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1582_ _0667_ vss vss vdd vdd _0275_ sky130_fd_sc_hd__clkbuf_1
XTAP_457 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2203_ clknet_1_0__leaf_vco_in _0004_ _0229_ vss vss vdd vdd d5.fll_core.counter1.count\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_479 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2134_ clknet_4_8_0_clk_in _0397_ _0160_ vss vss vdd vdd d2.t_load\[42\] sky130_fd_sc_hd__dfrtp_1
X_2065_ clknet_4_0_0_clk_in _0329_ _0094_ vss vss vdd vdd d2.r_reg\[73\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1016_ d2.t_load\[20\] vss vss vdd vdd _0811_ sky130_fd_sc_hd__inv_2
X_1918_ _0773_ vss vss vdd vdd _0188_ sky130_fd_sc_hd__inv_2
X_1849_ _0767_ vss vss vdd vdd _0125_ sky130_fd_sc_hd__inv_2
XFILLER_27_44 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_243 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_48_387 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_48_376 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_0_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_63_379 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_63_357 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_284 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1703_ _0738_ _0739_ vss vss vdd vdd _0009_ sky130_fd_sc_hd__nor2_1
X_1634_ _0702_ d2.r_reg\[2\] _0684_ vss vss vdd vdd _0703_ sky130_fd_sc_hd__mux2_1
X_1565_ _0655_ d2.r_reg\[24\] _0640_ vss vss vdd vdd _0656_ sky130_fd_sc_hd__mux2_1
XFILLER_58_107 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1496_ net2 vss vss vdd vdd _0608_ sky130_fd_sc_hd__clkbuf_4
XTAP_210 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2117_ clknet_4_15_0_clk_in _0380_ _0143_ vss vss vdd vdd d2.t_load\[25\] sky130_fd_sc_hd__dfrtp_1
X_2048_ clknet_4_3_0_clk_in _0312_ _0077_ vss vss vdd vdd d2.r_reg\[56\] sky130_fd_sc_hd__dfrtp_1
XFILLER_13_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_38_65 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_1_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_349 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_54_20 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_9_225 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1281_ _0468_ vss vss vdd vdd _0380_ sky130_fd_sc_hd__clkbuf_1
X_1350_ _0478_ vss vss vdd vdd _0508_ sky130_fd_sc_hd__buf_4
XFILLER_63_176 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_121 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_357 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_36_346 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0996_ d5.fll_core.counter1.count\[7\] d2.t_load\[27\] vss vss vdd vdd _0791_ sky130_fd_sc_hd__and2b_1
XFILLER_44_390 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1617_ _0691_ vss vss vdd vdd _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_280 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1548_ d2.r_reg\[30\] d2.t_load\[29\] _0630_ vss vss vdd vdd _0644_ sky130_fd_sc_hd__mux2_1
X_1479_ _0595_ d2.r_reg\[51\] _0596_ vss vss vdd vdd _0597_ sky130_fd_sc_hd__mux2_1
XFILLER_54_132 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_42_338 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_24_78 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_6_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_65_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_85 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_65_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_18_302 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_60_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_261 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1402_ _0543_ d2.r_reg\[75\] _0530_ vss vss vdd vdd _0544_ sky130_fd_sc_hd__mux2_1
X_1264_ _0982_ vss vss vdd vdd _0388_ sky130_fd_sc_hd__clkbuf_1
XFILLER_39_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
Xinput4 s_in vss vss vdd vdd net4 sky130_fd_sc_hd__clkbuf_1
X_1333_ d2.t_load\[0\] net17 _0490_ vss vss vdd vdd _0496_ sky130_fd_sc_hd__mux2_1
XFILLER_51_124 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_51_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1195_ d2.t_load\[65\] d2.r_reg\[65\] _0945_ vss vss vdd vdd _0946_ sky130_fd_sc_hd__mux2_1
XFILLER_27_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_87 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_65 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_33_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1882_ _0770_ vss vss vdd vdd _0155_ sky130_fd_sc_hd__inv_2
X_1951_ _0776_ vss vss vdd vdd _0218_ sky130_fd_sc_hd__inv_2
X_1247_ _0973_ vss vss vdd vdd _0396_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_249 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1316_ d2.t_load\[8\] d2.r_reg\[8\] _0479_ vss vss vdd vdd _0487_ sky130_fd_sc_hd__mux2_1
X_1178_ net23 d2.r_reg\[73\] _0934_ vss vss vdd vdd _0937_ sky130_fd_sc_hd__mux2_1
XFILLER_64_293 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XPHY_119 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_108 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_20_330 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_385 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_21_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_68 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_47_249 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_15_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_606 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1032_ d5.fll_core.tmp\[4\] _0816_ vss vss vdd vdd _0827_ sky130_fd_sc_hd__xnor2_2
XFILLER_38_205 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1101_ _0890_ vss vss vdd vdd _0459_ sky130_fd_sc_hd__clkbuf_1
X_2150_ clknet_4_3_0_clk_in _0413_ _0176_ vss vss vdd vdd d2.t_load\[58\] sky130_fd_sc_hd__dfrtp_1
X_2081_ clknet_4_4_0_clk_in _0345_ _0110_ vss vss vdd vdd d2.r_reg\[89\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_274 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1934_ _0775_ vss vss vdd vdd _0202_ sky130_fd_sc_hd__inv_2
XFILLER_21_149 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1865_ _0768_ vss vss vdd vdd _0140_ sky130_fd_sc_hd__inv_2
X_1796_ _0759_ vss vss vdd vdd _0083_ sky130_fd_sc_hd__inv_2
XFILLER_44_208 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_52_296 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_12_116 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_182 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_35_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_282 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1581_ _0666_ d2.r_reg\[19\] _0662_ vss vss vdd vdd _0667_ sky130_fd_sc_hd__mux2_1
X_1650_ d5.fll_core.tmp\[1\] d2.t_load\[48\] _0954_ vss vss vdd vdd _0712_ sky130_fd_sc_hd__mux2_1
XFILLER_7_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_160 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_11_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2202_ clknet_1_0__leaf_vco_in _0003_ _0228_ vss vss vdd vdd d5.fll_core.counter1.count\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_469 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_377 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1015_ _0781_ _0783_ _0785_ _0809_ vss vss vdd vdd _0810_ sky130_fd_sc_hd__a22oi_2
X_2133_ clknet_4_10_0_clk_in _0396_ _0159_ vss vss vdd vdd d2.t_load\[41\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2064_ clknet_4_0_0_clk_in _0328_ _0093_ vss vss vdd vdd d2.r_reg\[72\] sky130_fd_sc_hd__dfrtp_1
X_1917_ _0773_ vss vss vdd vdd _0187_ sky130_fd_sc_hd__inv_2
X_1779_ _0756_ vss vss vdd vdd _0069_ sky130_fd_sc_hd__inv_2
X_1848_ _0767_ vss vss vdd vdd _0124_ sky130_fd_sc_hd__inv_2
XFILLER_57_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_57_300 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_43_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_25_263 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_266 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_4_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_244 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_274 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1702_ d5.fll_core.counter1.count\[7\] _0736_ d5.fll_core.counter1.count\[8\] vss
+ vss vdd vdd _0739_ sky130_fd_sc_hd__a21oi_1
X_1564_ d2.r_reg\[25\] d2.t_load\[24\] _0652_ vss vss vdd vdd _0655_ sky130_fd_sc_hd__mux2_1
X_1633_ d2.r_reg\[3\] d2.t_load\[2\] _0497_ vss vss vdd vdd _0702_ sky130_fd_sc_hd__mux2_1
XFILLER_66_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1495_ _0607_ vss vss vdd vdd _0302_ sky130_fd_sc_hd__clkbuf_1
XTAP_200 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_174 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2116_ clknet_4_15_0_clk_in _0379_ _0142_ vss vss vdd vdd d2.t_load\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_388 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2047_ clknet_4_6_0_clk_in _0311_ _0076_ vss vss vdd vdd d2.r_reg\[55\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_9_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_233 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_266 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1280_ d2.t_load\[25\] d2.r_reg\[25\] _0467_ vss vss vdd vdd _0468_ sky130_fd_sc_hd__mux2_1
XFILLER_48_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_63_111 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_163 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0995_ d5.fll_core.counter1.count\[5\] vss vss vdd vdd _0790_ sky130_fd_sc_hd__inv_2
X_1547_ _0643_ vss vss vdd vdd _0286_ sky130_fd_sc_hd__clkbuf_1
X_1616_ _0690_ d2.r_reg\[8\] _0684_ vss vss vdd vdd _0691_ sky130_fd_sc_hd__mux2_1
XFILLER_5_81 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_54_111 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1478_ _0478_ vss vss vdd vdd _0596_ sky130_fd_sc_hd__clkbuf_4
XFILLER_39_174 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_27_369 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_303 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_54_166 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_65 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_65_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_199 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_45_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_26_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_383 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_350 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1401_ d2.r_reg\[76\] net25 _0542_ vss vss vdd vdd _0543_ sky130_fd_sc_hd__mux2_1
X_1263_ d2.t_load\[33\] d2.r_reg\[33\] _0979_ vss vss vdd vdd _0982_ sky130_fd_sc_hd__mux2_1
X_1194_ _0911_ vss vss vdd vdd _0945_ sky130_fd_sc_hd__clkbuf_4
X_1332_ _0495_ vss vss vdd vdd _0356_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_10_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_225 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_19_57 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_19_68 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_51_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_30_309 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_23_361 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1950_ _0776_ vss vss vdd vdd _0217_ sky130_fd_sc_hd__inv_2
XFILLER_33_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_125 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_14_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1881_ _0770_ vss vss vdd vdd _0154_ sky130_fd_sc_hd__inv_2
XFILLER_51_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1315_ _0486_ vss vss vdd vdd _0364_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_272 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1246_ d2.t_load\[41\] d2.r_reg\[41\] _0968_ vss vss vdd vdd _0973_ sky130_fd_sc_hd__mux2_1
X_1177_ _0936_ vss vss vdd vdd _0429_ sky130_fd_sc_hd__clkbuf_1
XPHY_109 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_24_136 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_12_309 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_20_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_77 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_11_342 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_607 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_80 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1031_ d5.fll_core.tmp\[6\] _0816_ vss vss vdd vdd _0826_ sky130_fd_sc_hd__xnor2_1
X_1100_ d5.fll_core.tmp\[7\] _0889_ _0881_ vss vss vdd vdd _0890_ sky130_fd_sc_hd__mux2_1
X_2080_ clknet_4_4_0_clk_in _0344_ _0109_ vss vss vdd vdd d2.r_reg\[88\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1933_ _0775_ vss vss vdd vdd _0201_ sky130_fd_sc_hd__inv_2
XFILLER_21_106 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_21_139 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1864_ _0768_ vss vss vdd vdd _0139_ sky130_fd_sc_hd__inv_2
X_1795_ _0759_ vss vss vdd vdd _0082_ sky130_fd_sc_hd__inv_2
XFILLER_29_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_52_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1229_ d2.t_load\[49\] d2.r_reg\[49\] _0957_ vss vss vdd vdd _0964_ sky130_fd_sc_hd__mux2_1
XFILLER_20_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1580_ d2.r_reg\[20\] d2.t_load\[19\] _0652_ vss vss vdd vdd _0666_ sky130_fd_sc_hd__mux2_1
XFILLER_7_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_22_90 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2201_ clknet_1_0__leaf_vco_in _0002_ _0227_ vss vss vdd vdd d5.fll_core.counter1.count\[1\]
+ sky130_fd_sc_hd__dfrtp_2
X_2132_ clknet_4_8_0_clk_in _0395_ _0158_ vss vss vdd vdd d2.t_load\[40\] sky130_fd_sc_hd__dfrtp_1
XTAP_459 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1014_ _0795_ _0806_ _0807_ _0808_ vss vss vdd vdd _0809_ sky130_fd_sc_hd__a211o_1
XFILLER_34_264 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_34_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_19_250 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2063_ clknet_4_2_0_clk_in _0327_ _0092_ vss vss vdd vdd d2.r_reg\[71\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_297 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1916_ _0773_ vss vss vdd vdd _0186_ sky130_fd_sc_hd__inv_2
X_1847_ _0767_ vss vss vdd vdd _0123_ sky130_fd_sc_hd__inv_2
X_1778_ _0756_ vss vss vdd vdd _0068_ sky130_fd_sc_hd__inv_2
XFILLER_57_389 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_27_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_79 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_25_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_168 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_63_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_63_326 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_16_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1701_ d5.fll_core.counter1.count\[7\] d5.fll_core.counter1.count\[8\] _0736_ vss
+ vss vdd vdd _0738_ sky130_fd_sc_hd__and3_1
X_1563_ _0654_ vss vss vdd vdd _0281_ sky130_fd_sc_hd__clkbuf_1
X_1494_ _0606_ d2.r_reg\[46\] _0596_ vss vss vdd vdd _0607_ sky130_fd_sc_hd__mux2_1
XTAP_201 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1632_ _0701_ vss vss vdd vdd _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_153 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2115_ clknet_4_15_0_clk_in _0378_ _0141_ vss vss vdd vdd d2.t_load\[23\] sky130_fd_sc_hd__dfrtp_1
XTAP_234 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_197 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2046_ clknet_4_6_0_clk_in _0310_ _0075_ vss vss vdd vdd d2.r_reg\[54\] sky130_fd_sc_hd__dfrtp_1
XFILLER_60_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_57_197 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_45_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_13_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_0_182 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_63_189 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_145 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_197 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_44_370 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_0994_ d2.t_load\[27\] _0787_ _0788_ d2.t_load\[26\] vss vss vdd vdd _0789_ sky130_fd_sc_hd__o22a_1
X_1546_ _0642_ d2.r_reg\[30\] _0640_ vss vss vdd vdd _0643_ sky130_fd_sc_hd__mux2_1
X_1477_ d2.r_reg\[52\] d2.t_load\[51\] _0586_ vss vss vdd vdd _0595_ sky130_fd_sc_hd__mux2_1
X_1615_ d2.r_reg\[9\] d2.t_load\[8\] _0674_ vss vss vdd vdd _0690_ sky130_fd_sc_hd__mux2_1
XFILLER_5_93 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_42_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_164 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_142 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_348 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2029_ clknet_4_10_0_clk_in _0293_ _0058_ vss vss vdd vdd d2.r_reg\[37\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_381 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_65_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_49_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_33_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_90 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1400_ _0497_ vss vss vdd vdd _0542_ sky130_fd_sc_hd__buf_4
X_1331_ d2.t_load\[1\] d2.r_reg\[1\] _0490_ vss vss vdd vdd _0495_ sky130_fd_sc_hd__mux2_1
X_1262_ _0981_ vss vss vdd vdd _0389_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_134 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_36_101 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1193_ _0944_ vss vss vdd vdd _0421_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_189 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_373 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_10_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1529_ d2.r_reg\[36\] d2.t_load\[35\] _0630_ vss vss vdd vdd _0631_ sky130_fd_sc_hd__mux2_1
XFILLER_59_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_204 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_126 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_35_79 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_35_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_299 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1880_ _0770_ vss vss vdd vdd _0153_ sky130_fd_sc_hd__inv_2
XPHY_90 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_44_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1314_ d2.t_load\[9\] d2.r_reg\[9\] _0479_ vss vss vdd vdd _0486_ sky130_fd_sc_hd__mux2_1
XFILLER_49_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1245_ _0972_ vss vss vdd vdd _0397_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_126 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_2_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1176_ net24 d2.r_reg\[74\] _0934_ vss vss vdd vdd _0936_ sky130_fd_sc_hd__mux2_1
XFILLER_20_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_251 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_295 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_15_148 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_608 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_13_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_13_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_11_92 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1030_ _0819_ _0820_ _0823_ _0824_ _0817_ vss vss vdd vdd _0825_ sky130_fd_sc_hd__a32o_1
XFILLER_61_298 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_254 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1863_ _0768_ vss vss vdd vdd _0138_ sky130_fd_sc_hd__inv_2
X_1932_ _0750_ vss vss vdd vdd _0775_ sky130_fd_sc_hd__buf_4
X_1794_ _0759_ vss vss vdd vdd _0081_ sky130_fd_sc_hd__inv_2
XFILLER_6_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1228_ _0963_ vss vss vdd vdd _0405_ sky130_fd_sc_hd__clkbuf_1
X_1159_ net32 d2.r_reg\[82\] _0923_ vss vss vdd vdd _0927_ sky130_fd_sc_hd__mux2_1
XFILLER_16_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_99 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_57_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_221 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_28_295 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_254 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_405 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_361 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_155 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_357 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2200_ clknet_1_0__leaf_vco_in _0001_ _0226_ vss vss vdd vdd d5.fll_core.counter1.count\[0\]
+ sky130_fd_sc_hd__dfrtp_2
X_2131_ clknet_4_10_0_clk_in _0394_ _0157_ vss vss vdd vdd d2.t_load\[39\] sky130_fd_sc_hd__dfrtp_1
XTAP_449 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2062_ clknet_4_2_0_clk_in _0326_ _0091_ vss vss vdd vdd d2.r_reg\[70\] sky130_fd_sc_hd__dfrtp_1
X_1013_ _0789_ _0791_ vss vss vdd vdd _0808_ sky130_fd_sc_hd__nor2_1
X_1777_ _0756_ vss vss vdd vdd _0067_ sky130_fd_sc_hd__inv_2
X_1915_ _0773_ vss vss vdd vdd _0185_ sky130_fd_sc_hd__inv_2
X_1846_ _0767_ vss vss vdd vdd _0122_ sky130_fd_sc_hd__inv_2
XFILLER_57_357 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_346 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_276 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_125 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_48_357 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_386 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_63_349 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1700_ _0787_ _0736_ vss vss vdd vdd _0008_ sky130_fd_sc_hd__xnor2_1
X_1631_ _0700_ d2.r_reg\[3\] _0684_ vss vss vdd vdd _0701_ sky130_fd_sc_hd__mux2_1
X_1562_ _0653_ d2.r_reg\[25\] _0640_ vss vss vdd vdd _0654_ sky130_fd_sc_hd__mux2_1
X_1493_ d2.r_reg\[47\] d2.t_load\[46\] _0586_ vss vss vdd vdd _0606_ sky130_fd_sc_hd__mux2_1
XTAP_202 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_66_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2114_ clknet_4_15_0_clk_in _0377_ _0140_ vss vss vdd vdd d2.t_load\[22\] sky130_fd_sc_hd__dfrtp_1
XFILLER_54_338 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_39_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2045_ clknet_4_6_0_clk_in _0309_ _0074_ vss vss vdd vdd d2.r_reg\[53\] sky130_fd_sc_hd__dfrtp_1
XTAP_268 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_279 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_257 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1829_ _0762_ vss vss vdd vdd _0113_ sky130_fd_sc_hd__inv_2
XFILLER_57_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_1_139 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xclkbuf_4_1_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_1_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_63_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0993_ d5.fll_core.counter1.count\[6\] vss vss vdd vdd _0788_ sky130_fd_sc_hd__inv_2
XFILLER_44_382 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1614_ _0689_ vss vss vdd vdd _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_8_294 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1545_ d2.r_reg\[31\] d2.t_load\[30\] _0630_ vss vss vdd vdd _0642_ sky130_fd_sc_hd__mux2_1
XFILLER_39_121 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1476_ _0594_ vss vss vdd vdd _0308_ sky130_fd_sc_hd__clkbuf_1
X_2028_ clknet_4_10_0_clk_in _0292_ _0057_ vss vss vdd vdd d2.r_reg\[36\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_327 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_352 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_341 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_69 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_44 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_49_78 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_374 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1261_ d2.t_load\[34\] d2.r_reg\[34\] _0979_ vss vss vdd vdd _0981_ sky130_fd_sc_hd__mux2_1
X_1330_ _0494_ vss vss vdd vdd _0357_ sky130_fd_sc_hd__clkbuf_1
X_1192_ d2.t_load\[66\] d2.r_reg\[66\] _0934_ vss vss vdd vdd _0944_ sky130_fd_sc_hd__mux2_1
XFILLER_17_360 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1528_ net2 vss vss vdd vdd _0630_ sky130_fd_sc_hd__clkbuf_4
XFILLER_27_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1459_ _0582_ d2.r_reg\[57\] _0574_ vss vss vdd vdd _0583_ sky130_fd_sc_hd__mux2_1
XFILLER_19_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_57 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_23_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_4_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_212 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_91 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_80 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_49_260 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1244_ d2.t_load\[42\] d2.r_reg\[42\] _0968_ vss vss vdd vdd _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_37_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1313_ _0485_ vss vss vdd vdd _0365_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_241 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_149 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1175_ _0935_ vss vss vdd vdd _0430_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_182 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_322 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_377 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_21_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_322 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_609 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1862_ _0768_ vss vss vdd vdd _0137_ sky130_fd_sc_hd__inv_2
X_1793_ _0757_ vss vss vdd vdd _0759_ sky130_fd_sc_hd__buf_4
X_1931_ _0774_ vss vss vdd vdd _0200_ sky130_fd_sc_hd__inv_2
X_1227_ d2.t_load\[50\] d2.r_reg\[50\] _0957_ vss vss vdd vdd _0963_ sky130_fd_sc_hd__mux2_1
X_1158_ _0926_ vss vss vdd vdd _0438_ sky130_fd_sc_hd__clkbuf_1
X_1089_ _0880_ vss vss vdd vdd _0881_ sky130_fd_sc_hd__clkbuf_4
XFILLER_32_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_108 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_16_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_57_67 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_244 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_211 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_28_230 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_439 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_373 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_7_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1012_ _0794_ _0792_ _0789_ vss vss vdd vdd _0807_ sky130_fd_sc_hd__and3b_1
X_2130_ clknet_4_10_0_clk_in _0393_ _0156_ vss vss vdd vdd d2.t_load\[38\] sky130_fd_sc_hd__dfrtp_1
X_2061_ clknet_4_2_0_clk_in _0325_ _0090_ vss vss vdd vdd d2.r_reg\[69\] sky130_fd_sc_hd__dfrtp_1
X_1914_ _0773_ vss vss vdd vdd _0184_ sky130_fd_sc_hd__inv_2
X_1776_ _0756_ vss vss vdd vdd _0066_ sky130_fd_sc_hd__inv_2
XFILLER_8_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1845_ _0767_ vss vss vdd vdd _0121_ sky130_fd_sc_hd__inv_2
XFILLER_57_325 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_57_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_380 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_57_369 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_222 vss vss vdd vdd sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f_vco_in clknet_0_vco_in vss vss vdd vdd clknet_1_0__leaf_vco_in sky130_fd_sc_hd__clkbuf_16
XFILLER_43_69 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_31_225 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_31_203 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_233 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_80 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1630_ d2.r_reg\[4\] d2.t_load\[3\] _0497_ vss vss vdd vdd _0700_ sky130_fd_sc_hd__mux2_1
X_1561_ d2.r_reg\[26\] d2.t_load\[25\] _0652_ vss vss vdd vdd _0653_ sky130_fd_sc_hd__mux2_1
X_1492_ _0605_ vss vss vdd vdd _0303_ sky130_fd_sc_hd__clkbuf_1
XFILLER_39_325 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_203 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2113_ clknet_4_15_0_clk_in _0376_ _0139_ vss vss vdd vdd d2.t_load\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_47_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_39_347 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2044_ clknet_4_12_0_clk_in _0308_ _0073_ vss vss vdd vdd d2.r_reg\[52\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_269 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1759_ _0751_ vss vss vdd vdd _0755_ sky130_fd_sc_hd__buf_4
X_1828_ _0762_ vss vss vdd vdd _0112_ sky130_fd_sc_hd__inv_2
XFILLER_45_306 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_38_69 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_54_68 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_13_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_13_247 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_162 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_169 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_155 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_29_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_0_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_0992_ d5.fll_core.counter1.count\[7\] vss vss vdd vdd _0787_ sky130_fd_sc_hd__inv_2
X_1544_ _0641_ vss vss vdd vdd _0287_ sky130_fd_sc_hd__clkbuf_1
X_1613_ _0688_ d2.r_reg\[9\] _0684_ vss vss vdd vdd _0689_ sky130_fd_sc_hd__mux2_1
XFILLER_5_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1475_ _0593_ d2.r_reg\[52\] _0574_ vss vss vdd vdd _0594_ sky130_fd_sc_hd__mux2_1
X_2027_ clknet_4_10_0_clk_in _0291_ _0056_ vss vss vdd vdd d2.r_reg\[35\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_49_57 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_65_89 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_117 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_191 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_71 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_30_81 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_14_93 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1260_ _0980_ vss vss vdd vdd _0390_ sky130_fd_sc_hd__clkbuf_1
X_1191_ _0943_ vss vss vdd vdd _0422_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_372 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1527_ _0629_ vss vss vdd vdd _0292_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_10_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_35_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1458_ d2.r_reg\[58\] d2.t_load\[57\] _0564_ vss vss vdd vdd _0582_ sky130_fd_sc_hd__mux2_1
XFILLER_27_125 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1389_ _0534_ d2.r_reg\[79\] _0530_ vss vss vdd vdd _0535_ sky130_fd_sc_hd__mux2_1
XFILLER_19_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_183 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_279 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_2_224 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_18_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_92 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_183 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_81 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_70 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_64_231 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1243_ _0971_ vss vss vdd vdd _0398_ sky130_fd_sc_hd__clkbuf_1
X_1312_ d2.t_load\[10\] d2.r_reg\[10\] _0479_ vss vss vdd vdd _0485_ sky130_fd_sc_hd__mux2_1
X_1174_ net25 d2.r_reg\[75\] _0934_ vss vss vdd vdd _0935_ sky130_fd_sc_hd__mux2_1
XFILLER_2_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_2_85 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_264 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_64_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_62_68 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_301 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_23_194 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_61_267 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_234 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_36_91 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1930_ _0774_ vss vss vdd vdd _0199_ sky130_fd_sc_hd__inv_2
X_1861_ _0768_ vss vss vdd vdd _0136_ sky130_fd_sc_hd__inv_2
X_1792_ _0758_ vss vss vdd vdd _0080_ sky130_fd_sc_hd__inv_2
XFILLER_14_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_223 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1226_ _0962_ vss vss vdd vdd _0406_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_253 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1157_ net33 d2.r_reg\[83\] _0923_ vss vss vdd vdd _0926_ sky130_fd_sc_hd__mux2_1
XFILLER_52_267 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1088_ _0853_ _0860_ _0000_ vss vss vdd vdd _0880_ sky130_fd_sc_hd__and3b_1
XFILLER_32_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_43_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_242 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_7_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_22_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_429 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_66_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1011_ _0796_ _0799_ _0801_ _0805_ vss vss vdd vdd _0806_ sky130_fd_sc_hd__a22o_1
X_2060_ clknet_4_2_0_clk_in _0324_ _0089_ vss vss vdd vdd d2.r_reg\[68\] sky130_fd_sc_hd__dfrtp_1
X_1913_ _0773_ vss vss vdd vdd _0183_ sky130_fd_sc_hd__inv_2
X_1775_ _0756_ vss vss vdd vdd _0065_ sky130_fd_sc_hd__inv_2
X_1844_ _0757_ vss vss vdd vdd _0767_ sky130_fd_sc_hd__buf_4
XFILLER_57_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2189_ clknet_1_1__leaf_ref_in _0451_ _0215_ vss vss vdd vdd d5.fll_core.locked sky130_fd_sc_hd__dfrtp_1
XFILLER_43_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_226 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1209_ d2.t_load\[58\] d2.r_reg\[58\] _0945_ vss vss vdd vdd _0953_ sky130_fd_sc_hd__mux2_1
XFILLER_25_201 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_48_315 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_71 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1560_ net2 vss vss vdd vdd _0652_ sky130_fd_sc_hd__clkbuf_4
XFILLER_33_92 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2112_ clknet_4_15_0_clk_in _0375_ _0138_ vss vss vdd vdd d2.t_load\[20\] sky130_fd_sc_hd__dfrtp_1
X_1491_ _0604_ d2.r_reg\[47\] _0596_ vss vss vdd vdd _0605_ sky130_fd_sc_hd__mux2_1
XFILLER_39_337 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_39_304 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_3_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_160 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_204 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_226 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2043_ clknet_4_12_0_clk_in _0307_ _0072_ vss vss vdd vdd d2.r_reg\[51\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_215 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_281 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1827_ _0762_ vss vss vdd vdd _0111_ sky130_fd_sc_hd__inv_2
XFILLER_22_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1758_ _0754_ vss vss vdd vdd _0050_ sky130_fd_sc_hd__inv_2
X_1689_ _0730_ _0731_ vss vss vdd vdd _0003_ sky130_fd_sc_hd__nor2_1
XFILLER_57_123 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_0_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_174 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_48_178 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_36_329 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_36_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_0991_ d2.t_load\[24\] vss vss vdd vdd _0786_ sky130_fd_sc_hd__inv_2
XFILLER_44_91 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1543_ _0639_ d2.r_reg\[31\] _0640_ vss vss vdd vdd _0641_ sky130_fd_sc_hd__mux2_1
XFILLER_60_90 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1474_ d2.r_reg\[53\] d2.t_load\[52\] _0586_ vss vss vdd vdd _0593_ sky130_fd_sc_hd__mux2_1
X_1612_ d2.r_reg\[10\] d2.t_load\[9\] _0674_ vss vss vdd vdd _0688_ sky130_fd_sc_hd__mux2_1
XFILLER_54_115 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_39_134 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_27_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2026_ clknet_4_11_0_clk_in _0290_ _0055_ vss vss vdd vdd d2.r_reg\[34\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_590 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_107 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_26_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_26_351 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_41_365 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_41_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1190_ d2.t_load\[67\] d2.r_reg\[67\] _0934_ vss vss vdd vdd _0943_ sky130_fd_sc_hd__mux2_1
XFILLER_32_365 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_17_384 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1526_ _0628_ d2.r_reg\[36\] _0618_ vss vss vdd vdd _0629_ sky130_fd_sc_hd__mux2_1
X_1457_ _0581_ vss vss vdd vdd _0314_ sky130_fd_sc_hd__clkbuf_1
XFILLER_42_118 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_35_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1388_ d2.r_reg\[80\] net29 _0520_ vss vss vdd vdd _0534_ sky130_fd_sc_hd__mux2_1
XFILLER_19_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_51_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2009_ clknet_4_12_0_clk_in _0273_ _0038_ vss vss vdd vdd d2.r_reg\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_2_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_82 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_71 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_33_118 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_60 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_93 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_162 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1311_ _0484_ vss vss vdd vdd _0366_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_273 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1242_ d2.t_load\[43\] d2.r_reg\[43\] _0968_ vss vss vdd vdd _0971_ sky130_fd_sc_hd__mux2_1
X_1173_ _0911_ vss vss vdd vdd _0934_ sky130_fd_sc_hd__buf_4
XFILLER_2_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_32_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_32_151 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_346 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_9_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1509_ d2.r_reg\[42\] d2.t_load\[41\] _0608_ vss vss vdd vdd _0617_ sky130_fd_sc_hd__mux2_1
XFILLER_46_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_276 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_221 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_7_328 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_23_173 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_276 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1860_ _0768_ vss vss vdd vdd _0135_ sky130_fd_sc_hd__inv_2
XFILLER_14_162 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1791_ _0758_ vss vss vdd vdd _0079_ sky130_fd_sc_hd__inv_2
XFILLER_42_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1225_ d2.t_load\[51\] d2.r_reg\[51\] _0957_ vss vss vdd vdd _0962_ sky130_fd_sc_hd__mux2_1
X_1087_ _0879_ vss vss vdd vdd _0000_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1156_ _0925_ vss vss vdd vdd _0439_ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1989_ _0751_ vss vss vdd vdd _0253_ sky130_fd_sc_hd__inv_2
XFILLER_4_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_265 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_28_210 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_290 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_7_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_419 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_331 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_349 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1010_ _0802_ _0803_ _0804_ vss vss vdd vdd _0805_ sky130_fd_sc_hd__a21o_1
XFILLER_19_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1912_ _0773_ vss vss vdd vdd _0182_ sky130_fd_sc_hd__inv_2
XFILLER_8_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_85 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1843_ _0762_ vss vss vdd vdd _0120_ sky130_fd_sc_hd__inv_2
X_1774_ _0756_ vss vss vdd vdd _0064_ sky130_fd_sc_hd__inv_2
X_1208_ _0952_ vss vss vdd vdd _0414_ sky130_fd_sc_hd__clkbuf_1
X_2188_ clknet_1_1__leaf_ref_in _0000_ _0214_ vss vss vdd vdd d5.fll_core.counter_reset
+ sky130_fd_sc_hd__dfstp_1
XFILLER_43_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_238 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1139_ _0916_ vss vss vdd vdd _0447_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_319 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_61 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_238 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1490_ d2.r_reg\[48\] d2.t_load\[47\] _0586_ vss vss vdd vdd _0604_ sky130_fd_sc_hd__mux2_1
XFILLER_3_150 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_205 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_146 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2111_ clknet_4_15_0_clk_in _0374_ _0137_ vss vss vdd vdd d2.t_load\[19\] sky130_fd_sc_hd__dfrtp_1
X_2042_ clknet_4_9_0_clk_in _0306_ _0071_ vss vss vdd vdd d2.r_reg\[50\] sky130_fd_sc_hd__dfrtp_1
XTAP_216 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_227 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1826_ _0757_ vss vss vdd vdd _0762_ sky130_fd_sc_hd__buf_4
X_1757_ _0754_ vss vss vdd vdd _0049_ sky130_fd_sc_hd__inv_2
X_1688_ d5.fll_core.counter1.count\[0\] d5.fll_core.counter1.count\[1\] d5.fll_core.counter1.count\[2\]
+ vss vss vdd vdd _0731_ sky130_fd_sc_hd__a21oi_1
XFILLER_38_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_57_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_21_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_120 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_63_149 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_371 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_28_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_0990_ _0783_ _0784_ _0781_ vss vss vdd vdd _0785_ sky130_fd_sc_hd__and3b_1
X_1611_ _0687_ vss vss vdd vdd _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1542_ _0478_ vss vss vdd vdd _0640_ sky130_fd_sc_hd__clkbuf_4
X_1473_ _0592_ vss vss vdd vdd _0309_ sky130_fd_sc_hd__clkbuf_1
X_2025_ clknet_4_11_0_clk_in _0289_ _0054_ vss vss vdd vdd d2.r_reg\[33\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_330 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_50_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1809_ _0760_ vss vss vdd vdd _0095_ sky130_fd_sc_hd__inv_2
XTAP_591 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_580 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_69 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_127 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_41_344 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_5_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_127 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_182 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1525_ d2.r_reg\[37\] d2.t_load\[36\] _0608_ vss vss vdd vdd _0628_ sky130_fd_sc_hd__mux2_1
X_1456_ _0580_ d2.r_reg\[58\] _0574_ vss vss vdd vdd _0581_ sky130_fd_sc_hd__mux2_1
X_1387_ _0533_ vss vss vdd vdd _0336_ sky130_fd_sc_hd__clkbuf_1
X_2008_ clknet_4_13_0_clk_in _0272_ _0037_ vss vss vdd vdd d2.r_reg\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_182 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_149 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_58_296 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_127 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_18_149 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_94 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_83 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_72 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_33_108 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_61 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_193 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_50 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_41_196 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1241_ _0970_ vss vss vdd vdd _0399_ sky130_fd_sc_hd__clkbuf_1
X_1310_ d2.t_load\[11\] d2.r_reg\[11\] _0479_ vss vss vdd vdd _0484_ sky130_fd_sc_hd__mux2_1
XFILLER_1_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_119 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_2_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1172_ _0933_ vss vss vdd vdd _0431_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_174 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_17_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1508_ _0616_ vss vss vdd vdd _0298_ sky130_fd_sc_hd__clkbuf_1
X_1439_ d2.r_reg\[64\] d2.t_load\[63\] _0564_ vss vss vdd vdd _0569_ sky130_fd_sc_hd__mux2_1
XFILLER_62_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_255 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_314 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_7_318 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_2_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_225 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_46_222 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_247 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_174 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1790_ _0758_ vss vss vdd vdd _0078_ sky130_fd_sc_hd__inv_2
X_1224_ _0961_ vss vss vdd vdd _0407_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_211 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_52_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1086_ _0875_ _0876_ _0878_ vss vss vdd vdd _0879_ sky130_fd_sc_hd__and3_1
X_1155_ net34 d2.r_reg\[84\] _0923_ vss vss vdd vdd _0925_ sky130_fd_sc_hd__mux2_1
X_1988_ _0751_ vss vss vdd vdd _0252_ sky130_fd_sc_hd__inv_2
XFILLER_32_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_122 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_57_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_43_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_299 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_409 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_4_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_4_0_clk_in sky130_fd_sc_hd__clkbuf_8
X_1773_ _0756_ vss vss vdd vdd _0063_ sky130_fd_sc_hd__inv_2
X_1911_ _0773_ vss vss vdd vdd _0181_ sky130_fd_sc_hd__inv_2
XFILLER_8_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_97 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1842_ _0762_ vss vss vdd vdd _0119_ sky130_fd_sc_hd__inv_2
XFILLER_57_306 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1207_ d2.t_load\[59\] d2.r_reg\[59\] _0945_ vss vss vdd vdd _0952_ sky130_fd_sc_hd__mux2_1
X_2187_ clknet_4_5_0_clk_in _0450_ _0213_ vss vss vdd vdd d2.t_load\[95\] sky130_fd_sc_hd__dfrtp_1
XFILLER_43_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1138_ net42 d2.r_reg\[92\] _0912_ vss vss vdd vdd _0916_ sky130_fd_sc_hd__mux2_1
X_1069_ d2.t_load\[3\] d5.fll_core.counter2.count\[3\] vss vss vdd vdd _0863_ sky130_fd_sc_hd__xnor2_1
XFILLER_4_118 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_56_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_17_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_50 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_206 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_66_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_309 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2110_ clknet_4_13_0_clk_in _0373_ _0136_ vss vss vdd vdd d2.t_load\[18\] sky130_fd_sc_hd__dfrtp_1
X_2041_ clknet_4_9_0_clk_in _0305_ _0070_ vss vss vdd vdd d2.r_reg\[49\] sky130_fd_sc_hd__dfrtp_1
X_1756_ _0754_ vss vss vdd vdd _0048_ sky130_fd_sc_hd__inv_2
XFILLER_30_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1825_ _0761_ vss vss vdd vdd _0110_ sky130_fd_sc_hd__inv_2
XFILLER_57_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1687_ d5.fll_core.counter1.count\[0\] d5.fll_core.counter1.count\[1\] d5.fll_core.counter1.count\[2\]
+ vss vss vdd vdd _0730_ sky130_fd_sc_hd__and3_1
XFILLER_65_180 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_57_169 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_57_136 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_63_117 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_125 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_61 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_0_187 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_44_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_29_383 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1610_ _0686_ d2.r_reg\[10\] _0684_ vss vss vdd vdd _0687_ sky130_fd_sc_hd__mux2_1
XFILLER_8_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_287 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_12_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1541_ d2.r_reg\[32\] d2.t_load\[31\] _0630_ vss vss vdd vdd _0639_ sky130_fd_sc_hd__mux2_1
X_1472_ _0591_ d2.r_reg\[53\] _0574_ vss vss vdd vdd _0592_ sky130_fd_sc_hd__mux2_1
X_2024_ clknet_4_11_0_clk_in _0288_ _0053_ vss vss vdd vdd d2.r_reg\[32\] sky130_fd_sc_hd__dfrtp_1
XFILLER_47_191 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_62_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_345 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_49_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1739_ _0753_ vss vss vdd vdd _0032_ sky130_fd_sc_hd__inv_2
X_1808_ _0760_ vss vss vdd vdd _0094_ sky130_fd_sc_hd__inv_2
XTAP_592 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_570 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_117 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_18_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_53_183 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_356 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_378 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_14_41 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_85 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_150 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_180 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_44_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_378 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1524_ _0627_ vss vss vdd vdd _0293_ sky130_fd_sc_hd__clkbuf_1
X_1455_ d2.r_reg\[59\] d2.t_load\[58\] _0564_ vss vss vdd vdd _0580_ sky130_fd_sc_hd__mux2_1
X_1386_ _0532_ d2.r_reg\[80\] _0530_ vss vss vdd vdd _0533_ sky130_fd_sc_hd__mux2_1
X_2007_ clknet_4_12_0_clk_in _0271_ _0036_ vss vss vdd vdd d2.r_reg\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_150 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_301 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_51_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_175 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_205 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_58_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_18_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_95 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_84 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_73 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_62 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_161 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_51 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_40 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1240_ d2.t_load\[44\] d2.r_reg\[44\] _0968_ vss vss vdd vdd _0970_ sky130_fd_sc_hd__mux2_1
XFILLER_2_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_1_260 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1171_ net26 d2.r_reg\[76\] _0923_ vss vss vdd vdd _0933_ sky130_fd_sc_hd__mux2_1
XFILLER_49_286 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_32_131 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_197 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_20_326 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1507_ _0615_ d2.r_reg\[42\] _0596_ vss vss vdd vdd _0616_ sky130_fd_sc_hd__mux2_1
X_1438_ _0568_ vss vss vdd vdd _0320_ sky130_fd_sc_hd__clkbuf_1
X_1369_ d2.r_reg\[86\] net35 _0520_ vss vss vdd vdd _0521_ sky130_fd_sc_hd__mux2_1
XFILLER_62_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_23_142 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_14_186 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_14_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_6_385 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1223_ d2.t_load\[52\] d2.r_reg\[52\] _0957_ vss vss vdd vdd _0961_ sky130_fd_sc_hd__mux2_1
XFILLER_28_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1154_ _0924_ vss vss vdd vdd _0440_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_292 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1085_ d2.t_load\[1\] _0867_ _0868_ d2.t_load\[7\] _0877_ vss vss vdd vdd _0878_
+ sky130_fd_sc_hd__o221a_1
X_1987_ _0751_ vss vss vdd vdd _0251_ sky130_fd_sc_hd__inv_2
XFILLER_57_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_28_223 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_281 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_11_123 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_41 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_3_311 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_22_96 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1910_ _0750_ vss vss vdd vdd _0773_ sky130_fd_sc_hd__buf_4
XFILLER_34_226 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1772_ _0756_ vss vss vdd vdd _0062_ sky130_fd_sc_hd__inv_2
XFILLER_8_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1841_ _0762_ vss vss vdd vdd _0118_ sky130_fd_sc_hd__inv_2
X_1206_ _0951_ vss vss vdd vdd _0415_ sky130_fd_sc_hd__clkbuf_1
X_1137_ _0915_ vss vss vdd vdd _0448_ sky130_fd_sc_hd__clkbuf_1
X_2186_ clknet_4_7_0_clk_in _0449_ _0212_ vss vss vdd vdd net44 sky130_fd_sc_hd__dfrtp_1
XFILLER_33_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1068_ d5.fll_core.counter2.count\[9\] vss vss vdd vdd _0862_ sky130_fd_sc_hd__inv_2
XFILLER_31_207 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_207 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_58_81 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_2040_ clknet_4_9_0_clk_in _0304_ _0069_ vss vss vdd vdd d2.r_reg\[48\] sky130_fd_sc_hd__dfrtp_1
XFILLER_62_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_15_281 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1755_ _0754_ vss vss vdd vdd _0047_ sky130_fd_sc_hd__inv_2
X_1686_ d5.fll_core.counter1.count\[0\] d5.fll_core.counter1.count\[1\] vss vss vdd
+ vdd _0002_ sky130_fd_sc_hd__xor2_1
X_1824_ _0761_ vss vss vdd vdd _0109_ sky130_fd_sc_hd__inv_2
XFILLER_38_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_38_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2169_ clknet_4_3_0_clk_in _0432_ _0195_ vss vss vdd vdd net27 sky130_fd_sc_hd__dfrtp_1
XFILLER_63_107 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_115 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_362 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_155 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_240 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1540_ _0638_ vss vss vdd vdd _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_8_233 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1471_ d2.r_reg\[54\] d2.t_load\[53\] _0586_ vss vss vdd vdd _0591_ sky130_fd_sc_hd__mux2_1
XFILLER_10_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2023_ clknet_4_11_0_clk_in _0287_ _0052_ vss vss vdd vdd d2.r_reg\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_354 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_35_321 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1807_ _0760_ vss vss vdd vdd _0093_ sky130_fd_sc_hd__inv_2
X_1669_ _0721_ vss vss vdd vdd net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1738_ _0753_ vss vss vdd vdd _0031_ sky130_fd_sc_hd__inv_2
XTAP_593 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_571 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_560 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_170 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_321 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_173 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_41_324 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_365 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_26_343 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_30_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_30_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_225 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_82 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1523_ _0626_ d2.r_reg\[37\] _0618_ vss vss vdd vdd _0627_ sky130_fd_sc_hd__mux2_1
X_1454_ _0579_ vss vss vdd vdd _0315_ sky130_fd_sc_hd__clkbuf_1
X_1385_ d2.r_reg\[81\] net30 _0520_ vss vss vdd vdd _0532_ sky130_fd_sc_hd__mux2_1
XFILLER_50_154 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2006_ clknet_4_13_0_clk_in _0270_ _0035_ vss vss vdd vdd d2.r_reg\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_23_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_58_287 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_58_243 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_390 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_96 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_85 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_176 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XPHY_74 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_63 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_52 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_41 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_64_202 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1170_ _0932_ vss vss vdd vdd _0432_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_165 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_32_110 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_361 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1506_ d2.r_reg\[43\] d2.t_load\[42\] _0608_ vss vss vdd vdd _0615_ sky130_fd_sc_hd__mux2_1
X_1437_ _0567_ d2.r_reg\[64\] _0552_ vss vss vdd vdd _0568_ sky130_fd_sc_hd__mux2_1
X_1299_ _0477_ vss vss vdd vdd _0371_ sky130_fd_sc_hd__clkbuf_1
XFILLER_46_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1368_ _0497_ vss vss vdd vdd _0520_ sky130_fd_sc_hd__clkbuf_4
XFILLER_61_205 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_62 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_331 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1222_ _0960_ vss vss vdd vdd _0408_ sky130_fd_sc_hd__clkbuf_1
X_1084_ d2.t_load\[6\] _0865_ _0862_ d2.t_load\[9\] vss vss vdd vdd _0877_ sky130_fd_sc_hd__a22oi_1
X_1153_ net35 d2.r_reg\[85\] _0923_ vss vss vdd vdd _0924_ sky130_fd_sc_hd__mux2_1
X_1986_ _0777_ vss vss vdd vdd _0250_ sky130_fd_sc_hd__inv_2
XFILLER_20_135 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_146 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_43_238 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_11_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_371 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1840_ _0762_ vss vss vdd vdd _0117_ sky130_fd_sc_hd__inv_2
X_1771_ _0756_ vss vss vdd vdd _0061_ sky130_fd_sc_hd__inv_2
XFILLER_8_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1205_ d2.t_load\[60\] d2.r_reg\[60\] _0945_ vss vss vdd vdd _0951_ sky130_fd_sc_hd__mux2_1
XFILLER_25_205 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1067_ d2.t_load\[0\] vss vss vdd vdd _0861_ sky130_fd_sc_hd__inv_2
X_2185_ clknet_4_5_0_clk_in _0448_ _0211_ vss vss vdd vdd net43 sky130_fd_sc_hd__dfrtp_1
X_1136_ net43 d2.r_reg\[93\] _0912_ vss vss vdd vdd _0915_ sky130_fd_sc_hd__mux2_1
X_1969_ _0778_ vss vss vdd vdd _0234_ sky130_fd_sc_hd__inv_2
XFILLER_40_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_24_271 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_238 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_17_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_63 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_39_319 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XTAP_208 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_62_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_30_274 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1823_ _0761_ vss vss vdd vdd _0108_ sky130_fd_sc_hd__inv_2
XFILLER_22_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1754_ _0754_ vss vss vdd vdd _0046_ sky130_fd_sc_hd__inv_2
X_1685_ _0729_ vss vss vdd vdd net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_54_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1119_ _0899_ _0903_ vss vss vdd vdd _0904_ sky130_fd_sc_hd__nor2_1
X_2099_ clknet_4_7_0_clk_in _0362_ _0125_ vss vss vdd vdd d2.t_load\[7\] sky130_fd_sc_hd__dfrtp_1
X_2168_ clknet_4_2_0_clk_in _0431_ _0194_ vss vss vdd vdd net26 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_48_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_44_355 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_341 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_44_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_8_245 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1470_ _0590_ vss vss vdd vdd _0310_ sky130_fd_sc_hd__clkbuf_1
X_2022_ clknet_4_11_0_clk_in _0286_ _0051_ vss vss vdd vdd d2.r_reg\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_62_152 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_62_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_54_119 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1806_ _0760_ vss vss vdd vdd _0092_ sky130_fd_sc_hd__inv_2
X_1668_ d2.t_load\[58\] d2.t_load\[34\] d2.t_load\[44\] vss vss vdd vdd _0721_ sky130_fd_sc_hd__mux2_1
XTAP_561 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_550 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1599_ d2.r_reg\[14\] d2.t_load\[13\] _0674_ vss vss vdd vdd _0679_ sky130_fd_sc_hd__mux2_1
X_1737_ _0751_ vss vss vdd vdd _0753_ sky130_fd_sc_hd__buf_4
XTAP_594 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_355 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_30_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_30_53 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_5_237 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_39_84 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_39_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_174 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_44_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_17_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_40_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1522_ d2.r_reg\[38\] d2.t_load\[37\] _0608_ vss vss vdd vdd _0626_ sky130_fd_sc_hd__mux2_1
X_1453_ _0578_ d2.r_reg\[59\] _0574_ vss vss vdd vdd _0579_ sky130_fd_sc_hd__mux2_1
X_2005_ clknet_4_12_0_clk_in _0269_ _0034_ vss vss vdd vdd d2.r_reg\[13\] sky130_fd_sc_hd__dfrtp_1
X_1384_ _0531_ vss vss vdd vdd _0337_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_211 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_391 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_64 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_53 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_185 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_26_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_20 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_336 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_31 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_42 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_97 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_86 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_75 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_75 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_66_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_49_299 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_211 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_1_273 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_20_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_373 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1505_ _0614_ vss vss vdd vdd _0299_ sky130_fd_sc_hd__clkbuf_1
X_1436_ d2.r_reg\[65\] d2.t_load\[64\] _0564_ vss vss vdd vdd _0567_ sky130_fd_sc_hd__mux2_1
X_1367_ _0519_ vss vss vdd vdd _0342_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_214 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1298_ d2.t_load\[16\] d2.r_reg\[16\] _0467_ vss vss vdd vdd _0477_ sky130_fd_sc_hd__mux2_1
XFILLER_62_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_23_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_11_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_269 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_36_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_14_155 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_343 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1221_ d2.t_load\[53\] d2.r_reg\[53\] _0957_ vss vss vdd vdd _0960_ sky130_fd_sc_hd__mux2_1
XFILLER_37_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1152_ _0911_ vss vss vdd vdd _0923_ sky130_fd_sc_hd__buf_4
X_1083_ d2.t_load\[2\] d5.fll_core.counter2.count\[2\] vss vss vdd vdd _0876_ sky130_fd_sc_hd__xnor2_1
X_1985_ _0777_ vss vss vdd vdd _0249_ sky130_fd_sc_hd__inv_2
XFILLER_20_158 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_28_203 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1419_ _0555_ vss vss vdd vdd _0326_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_217 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_258 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_7_118 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_147 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_22_54 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_3_335 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_0_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_59_383 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_47_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_83 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1770_ _0751_ vss vss vdd vdd _0756_ sky130_fd_sc_hd__buf_4
XFILLER_42_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1204_ _0950_ vss vss vdd vdd _0416_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2184_ clknet_4_4_0_clk_in _0447_ _0210_ vss vss vdd vdd net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_65_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1066_ _0816_ _0854_ _0855_ _0859_ vss vss vdd vdd _0860_ sky130_fd_sc_hd__o31a_1
XFILLER_40_209 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1135_ _0914_ vss vss vdd vdd _0449_ sky130_fd_sc_hd__clkbuf_1
X_1968_ _0778_ vss vss vdd vdd _0233_ sky130_fd_sc_hd__inv_2
X_1899_ _0750_ vss vss vdd vdd _0772_ sky130_fd_sc_hd__buf_4
XFILLER_0_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_48_309 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_33_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_24_294 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_121 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_3_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_66_128 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_59_180 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_209 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_334 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_15_250 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1753_ _0754_ vss vss vdd vdd _0045_ sky130_fd_sc_hd__inv_2
XFILLER_30_264 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_30_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1822_ _0761_ vss vss vdd vdd _0107_ sky130_fd_sc_hd__inv_2
X_1684_ d5.fll_core.locked d2.t_load\[45\] d2.t_load\[46\] vss vss vdd vdd _0729_
+ sky130_fd_sc_hd__mux2_1
XFILLER_38_331 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2167_ clknet_4_2_0_clk_in _0430_ _0193_ vss vss vdd vdd net25 sky130_fd_sc_hd__dfrtp_1
XFILLER_53_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1049_ d2.t_load\[13\] _0838_ _0839_ d2.t_load\[12\] _0842_ vss vss vdd vdd _0843_
+ sky130_fd_sc_hd__o221a_1
X_1118_ _0820_ _0823_ vss vss vdd vdd _0903_ sky130_fd_sc_hd__nor2_1
X_2098_ clknet_4_7_0_clk_in _0361_ _0124_ vss vss vdd vdd d2.t_load\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_297 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_320 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_172 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_378 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_28_53 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_44_85 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_12_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2021_ clknet_4_11_0_clk_in _0285_ _0050_ vss vss vdd vdd d2.r_reg\[29\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_117 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_62_197 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_50_359 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_304 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_389 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1736_ _0752_ vss vss vdd vdd _0030_ sky130_fd_sc_hd__inv_2
X_1805_ _0760_ vss vss vdd vdd _0091_ sky130_fd_sc_hd__inv_2
XTAP_584 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1598_ _0678_ vss vss vdd vdd _0270_ sky130_fd_sc_hd__clkbuf_1
X_1667_ _0720_ vss vss vdd vdd d5.mux01.out\[9\] sky130_fd_sc_hd__clkbuf_1
XTAP_595 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2219_ clknet_1_0__leaf_ref_in _0020_ _0245_ vss vss vdd vdd d5.fll_core.counter2.count\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_41_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_5_249 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_39_63 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_55_95 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_62 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_32_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_315 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1521_ _0625_ vss vss vdd vdd _0294_ sky130_fd_sc_hd__clkbuf_1
X_1452_ d2.r_reg\[60\] d2.t_load\[59\] _0564_ vss vss vdd vdd _0578_ sky130_fd_sc_hd__mux2_1
X_1383_ _0529_ d2.r_reg\[81\] _0530_ vss vss vdd vdd _0531_ sky130_fd_sc_hd__mux2_1
X_2004_ clknet_4_13_0_clk_in _0268_ _0033_ vss vss vdd vdd d2.r_reg\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_175 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1719_ _0868_ _0746_ vss vss vdd vdd _0018_ sky130_fd_sc_hd__xnor2_1
XFILLER_58_201 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_392 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_87 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_76 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_65 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_197 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XPHY_54 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_10 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_21 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_315 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_32 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_43 vss vss vdd vdd sky130_fd_sc_hd__decap_3
Xclkbuf_4_7_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_7_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_64_248 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_189 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_32_178 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_318 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_63_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1504_ _0613_ d2.r_reg\[43\] _0596_ vss vss vdd vdd _0614_ sky130_fd_sc_hd__mux2_1
XFILLER_9_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1435_ _0566_ vss vss vdd vdd _0321_ sky130_fd_sc_hd__clkbuf_1
X_1366_ _0518_ d2.r_reg\[86\] _0508_ vss vss vdd vdd _0519_ sky130_fd_sc_hd__mux2_1
XFILLER_63_292 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1297_ _0476_ vss vss vdd vdd _0372_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_101 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_259 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_215 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_53 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_52_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_14_145 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_52_96 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_355 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_377 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1220_ _0959_ vss vss vdd vdd _0409_ sky130_fd_sc_hd__clkbuf_1
X_1151_ _0922_ vss vss vdd vdd _0441_ sky130_fd_sc_hd__clkbuf_1
XFILLER_45_292 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_45_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1082_ _0864_ _0870_ _0874_ vss vss vdd vdd _0875_ sky130_fd_sc_hd__and3_1
X_1984_ _0777_ vss vss vdd vdd _0248_ sky130_fd_sc_hd__inv_2
XFILLER_9_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1418_ _0554_ d2.r_reg\[70\] _0552_ vss vss vdd vdd _0555_ sky130_fd_sc_hd__mux2_1
X_1349_ d2.r_reg\[92\] net41 _0498_ vss vss vdd vdd _0507_ sky130_fd_sc_hd__mux2_1
XFILLER_51_251 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_27_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_273 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_170 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_141 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_310 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1203_ d2.t_load\[61\] d2.r_reg\[61\] _0945_ vss vss vdd vdd _0950_ sky130_fd_sc_hd__mux2_1
XFILLER_26_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2183_ clknet_4_5_0_clk_in _0446_ _0209_ vss vss vdd vdd net41 sky130_fd_sc_hd__dfrtp_1
X_1134_ net44 d2.r_reg\[94\] _0912_ vss vss vdd vdd _0914_ sky130_fd_sc_hd__mux2_1
X_1065_ d5.fll_core.tmp\[3\] _0816_ _0858_ vss vss vdd vdd _0859_ sky130_fd_sc_hd__nand3_1
XFILLER_25_229 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1967_ _0778_ vss vss vdd vdd _0232_ sky130_fd_sc_hd__inv_2
X_1898_ _0771_ vss vss vdd vdd _0170_ sky130_fd_sc_hd__inv_2
XFILLER_0_317 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_354 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_321 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_17_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_33_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_33_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_144 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_47_310 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_62_313 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1752_ _0754_ vss vss vdd vdd _0044_ sky130_fd_sc_hd__inv_2
X_1683_ _0728_ vss vss vdd vdd net15 sky130_fd_sc_hd__clkbuf_1
X_1821_ _0761_ vss vss vdd vdd _0106_ sky130_fd_sc_hd__inv_2
X_1117_ _0902_ vss vss vdd vdd _0455_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_365 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_343 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2166_ clknet_4_2_0_clk_in _0429_ _0192_ vss vss vdd vdd net24 sky130_fd_sc_hd__dfrtp_1
X_2097_ clknet_4_7_0_clk_in _0360_ _0123_ vss vss vdd vdd d2.t_load\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_379 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1048_ d2.t_load\[11\] _0840_ _0839_ d2.t_load\[12\] _0841_ vss vss vdd vdd _0842_
+ sky130_fd_sc_hd__a221o_1
XFILLER_48_107 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_0_136 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_56_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_56_162 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_346 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_335 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_324 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_60_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_52_390 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_12_298 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_69 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2020_ clknet_4_14_0_clk_in _0284_ _0049_ vss vss vdd vdd d2.r_reg\[28\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_346 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1666_ d5.fll_core.tmp\[9\] d2.t_load\[56\] d2.t_load\[57\] vss vss vdd vdd _0720_
+ sky130_fd_sc_hd__mux2_1
X_1735_ _0752_ vss vss vdd vdd _0029_ sky130_fd_sc_hd__inv_2
X_1804_ _0757_ vss vss vdd vdd _0760_ sky130_fd_sc_hd__buf_4
XTAP_596 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1597_ _0677_ d2.r_reg\[14\] _0662_ vss vss vdd vdd _0678_ sky130_fd_sc_hd__mux2_1
XFILLER_53_198 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_53_187 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_53_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_41_316 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2218_ clknet_1_0__leaf_ref_in _0019_ _0244_ vss vss vdd vdd d5.fll_core.counter2.count\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_2149_ clknet_4_3_0_clk_in _0412_ _0175_ vss vss vdd vdd d2.t_load\[57\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_14_89 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_140 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_313 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1520_ _0624_ d2.r_reg\[38\] _0618_ vss vss vdd vdd _0625_ sky130_fd_sc_hd__mux2_1
X_1451_ _0577_ vss vss vdd vdd _0316_ sky130_fd_sc_hd__clkbuf_1
X_1382_ _0478_ vss vss vdd vdd _0530_ sky130_fd_sc_hd__clkbuf_4
XFILLER_35_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_2003_ clknet_4_12_0_clk_in _0267_ _0032_ vss vss vdd vdd d2.r_reg\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_50_146 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_50_135 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1649_ _0711_ vss vss vdd vdd d5.mux01.out\[0\] sky130_fd_sc_hd__clkbuf_1
X_1718_ _0746_ _0747_ vss vss vdd vdd _0017_ sky130_fd_sc_hd__nor2_1
XFILLER_58_279 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_58_235 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_393 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_88 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XPHY_77 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_66 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_55 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_11 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_22 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_305 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_33 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_44 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_98 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_227 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_17_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_32_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_56_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1503_ d2.r_reg\[44\] d2.t_load\[43\] _0608_ vss vss vdd vdd _0613_ sky130_fd_sc_hd__mux2_1
XFILLER_55_238 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1296_ d2.t_load\[17\] d2.r_reg\[17\] _0467_ vss vss vdd vdd _0476_ sky130_fd_sc_hd__mux2_1
X_1434_ _0565_ d2.r_reg\[65\] _0552_ vss vss vdd vdd _0566_ sky130_fd_sc_hd__mux2_1
X_1365_ d2.r_reg\[87\] net36 _0498_ vss vss vdd vdd _0518_ sky130_fd_sc_hd__mux2_1
XFILLER_63_271 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_113 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_11_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_11_68 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_249 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XTAP_190 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_301 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_10_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1150_ net36 d2.r_reg\[86\] _0912_ vss vss vdd vdd _0922_ sky130_fd_sc_hd__mux2_1
X_1081_ d2.t_load\[0\] _0011_ d5.fll_core.counter2.count\[5\] _0871_ _0873_ vss vss
+ vdd vdd _0874_ sky130_fd_sc_hd__o221a_1
X_1983_ _0777_ vss vss vdd vdd _0247_ sky130_fd_sc_hd__inv_2
X_1417_ d2.r_reg\[71\] net20 _0542_ vss vss vdd vdd _0554_ sky130_fd_sc_hd__mux2_1
X_1279_ _0911_ vss vss vdd vdd _0467_ sky130_fd_sc_hd__clkbuf_4
XFILLER_28_249 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_28_238 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1348_ _0506_ vss vss vdd vdd _0348_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_241 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_282 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_337 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_3_315 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_304 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_67 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_47_20 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_19_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_34_219 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_296 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_6_131 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_153 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_182 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1064_ d5.fll_core.tmp\[9\] d5.fll_core.tmp\[8\] _0856_ _0857_ vss vss vdd vdd _0858_
+ sky130_fd_sc_hd__and4_1
X_1202_ _0949_ vss vss vdd vdd _0417_ sky130_fd_sc_hd__clkbuf_1
X_2182_ clknet_4_4_0_clk_in _0445_ _0208_ vss vss vdd vdd net40 sky130_fd_sc_hd__dfrtp_1
X_1133_ _0913_ vss vss vdd vdd _0450_ sky130_fd_sc_hd__clkbuf_1
XFILLER_19_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1966_ _0778_ vss vss vdd vdd _0231_ sky130_fd_sc_hd__inv_2
X_1897_ _0771_ vss vss vdd vdd _0169_ sky130_fd_sc_hd__inv_2
XFILLER_0_329 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_0_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_56_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_333 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_33_99 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_33_88 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_33_44 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_58_85 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_62_358 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1820_ _0761_ vss vss vdd vdd _0105_ sky130_fd_sc_hd__inv_2
X_1751_ _0754_ vss vss vdd vdd _0043_ sky130_fd_sc_hd__inv_2
X_1682_ d2.t_load\[65\] d2.t_load\[41\] d2.t_load\[44\] vss vss vdd vdd _0728_ sky130_fd_sc_hd__mux2_1
XFILLER_38_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_65_152 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1047_ d2.t_load\[11\] _0840_ _0001_ d2.t_load\[10\] vss vss vdd vdd _0841_ sky130_fd_sc_hd__o211a_1
X_1116_ d5.fll_core.tmp\[3\] _0901_ _0881_ vss vss vdd vdd _0902_ sky130_fd_sc_hd__mux2_1
XFILLER_38_355 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2165_ clknet_4_0_0_clk_in _0428_ _0191_ vss vss vdd vdd net23 sky130_fd_sc_hd__dfrtp_1
X_2096_ clknet_4_7_0_clk_in _0359_ _0122_ vss vss vdd vdd d2.t_load\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1949_ _0776_ vss vss vdd vdd _0216_ sky130_fd_sc_hd__inv_2
XFILLER_21_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_56_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_44_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_233 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_20 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_5_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_259 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_288 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_133 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_62_111 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_47_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_369 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_35_303 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1803_ _0759_ vss vss vdd vdd _0090_ sky130_fd_sc_hd__inv_2
X_1596_ d2.r_reg\[15\] d2.t_load\[14\] _0674_ vss vss vdd vdd _0677_ sky130_fd_sc_hd__mux2_1
X_1665_ _0719_ vss vss vdd vdd d5.mux01.out\[8\] sky130_fd_sc_hd__clkbuf_1
X_1734_ _0752_ vss vss vdd vdd _0028_ sky130_fd_sc_hd__inv_2
XFILLER_7_281 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_597 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_586 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2217_ clknet_1_0__leaf_ref_in _0018_ _0243_ vss vss vdd vdd d5.fll_core.counter2.count\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2148_ clknet_4_3_0_clk_in _0411_ _0174_ vss vss vdd vdd d2.t_load\[56\] sky130_fd_sc_hd__dfrtp_1
X_2079_ clknet_4_4_0_clk_in _0343_ _0108_ vss vss vdd vdd d2.r_reg\[87\] sky130_fd_sc_hd__dfrtp_1
XFILLER_65_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1450_ _0576_ d2.r_reg\[60\] _0574_ vss vss vdd vdd _0577_ sky130_fd_sc_hd__mux2_1
XFILLER_4_251 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1381_ d2.r_reg\[82\] net31 _0520_ vss vss vdd vdd _0529_ sky130_fd_sc_hd__mux2_1
XFILLER_35_111 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2002_ clknet_4_13_0_clk_in _0266_ _0031_ vss vss vdd vdd d2.r_reg\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_31_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1579_ _0665_ vss vss vdd vdd _0276_ sky130_fd_sc_hd__clkbuf_1
X_1648_ d5.fll_core.tmp\[0\] d2.t_load\[47\] _0954_ vss vss vdd vdd _0711_ sky130_fd_sc_hd__mux2_1
XTAP_350 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1717_ d5.fll_core.counter2.count\[6\] _0744_ vss vss vdd vdd _0747_ sky130_fd_sc_hd__nor2_1
XTAP_394 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_133 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_12 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_89 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_169 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_41_158 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_78 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_67 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_56 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_23 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_34 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_45 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_64_206 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_49_247 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_49_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_85 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_66_74 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_147 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_32_158 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1502_ _0612_ vss vss vdd vdd _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1433_ d2.r_reg\[66\] d2.t_load\[65\] _0564_ vss vss vdd vdd _0565_ sky130_fd_sc_hd__mux2_1
X_1295_ _0475_ vss vss vdd vdd _0373_ sky130_fd_sc_hd__clkbuf_1
X_1364_ _0517_ vss vss vdd vdd _0343_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_169 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_180 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_209 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_14_125 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_65 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_10_331 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1080_ _0871_ d5.fll_core.counter2.count\[5\] d5.fll_core.counter2.count\[8\] _0866_
+ _0872_ vss vss vdd vdd _0873_ sky130_fd_sc_hd__a221oi_1
XFILLER_60_286 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_60_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_45_272 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1982_ _0777_ vss vss vdd vdd _0246_ sky130_fd_sc_hd__inv_2
XFILLER_20_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_3_81 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1347_ _0505_ d2.r_reg\[92\] _0490_ vss vss vdd vdd _0506_ sky130_fd_sc_hd__mux2_1
X_1416_ _0553_ vss vss vdd vdd _0327_ sky130_fd_sc_hd__clkbuf_1
X_1278_ _0466_ vss vss vdd vdd _0381_ sky130_fd_sc_hd__clkbuf_1
XFILLER_3_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_32 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_19_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_53 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_42_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_8_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_165 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1201_ d2.t_load\[62\] d2.r_reg\[62\] _0945_ vss vss vdd vdd _0949_ sky130_fd_sc_hd__mux2_1
XFILLER_65_389 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_65_356 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1063_ d5.fll_core.tmp\[2\] d5.fll_core.tmp\[1\] d5.fll_core.tmp\[0\] vss vss vdd
+ vdd _0857_ sky130_fd_sc_hd__and3_1
XFILLER_25_209 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2181_ clknet_4_5_0_clk_in _0444_ _0207_ vss vss vdd vdd net39 sky130_fd_sc_hd__dfrtp_1
X_1132_ d2.t_load\[95\] d2.r_reg\[95\] _0912_ vss vss vdd vdd _0913_ sky130_fd_sc_hd__mux2_1
X_1965_ _0778_ vss vss vdd vdd _0230_ sky130_fd_sc_hd__inv_2
X_1896_ _0771_ vss vss vdd vdd _0168_ sky130_fd_sc_hd__inv_2
XFILLER_56_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_24_253 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_16_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_17_57 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_67 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_53 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_3_113 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_47_378 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1750_ _0754_ vss vss vdd vdd _0042_ sky130_fd_sc_hd__inv_2
XFILLER_15_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1681_ _0727_ vss vss vdd vdd net14 sky130_fd_sc_hd__clkbuf_1
XFILLER_31_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2164_ clknet_4_2_0_clk_in _0427_ _0190_ vss vss vdd vdd net22 sky130_fd_sc_hd__dfrtp_1
X_1046_ d5.fll_core.counter1.count\[0\] vss vss vdd vdd _0001_ sky130_fd_sc_hd__inv_2
XFILLER_53_359 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_53_304 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1115_ _0819_ _0900_ vss vss vdd vdd _0901_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2095_ clknet_4_7_0_clk_in _0358_ _0121_ vss vss vdd vdd d2.t_load\[3\] sky130_fd_sc_hd__dfrtp_1
X_1879_ _0770_ vss vss vdd vdd _0152_ sky130_fd_sc_hd__inv_2
X_1948_ _0776_ vss vss vdd vdd _0215_ sky130_fd_sc_hd__inv_2
XFILLER_21_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_0_105 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_0_127 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_56_197 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_29_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_78 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_67 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_370 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_44_77 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_12_278 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_60_65 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_5_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_35_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1802_ _0759_ vss vss vdd vdd _0089_ sky130_fd_sc_hd__inv_2
X_1733_ _0752_ vss vss vdd vdd _0027_ sky130_fd_sc_hd__inv_2
XTAP_543 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1595_ _0676_ vss vss vdd vdd _0271_ sky130_fd_sc_hd__clkbuf_1
X_1664_ d5.fll_core.tmp\[8\] d2.t_load\[55\] _0954_ vss vss vdd vdd _0719_ sky130_fd_sc_hd__mux2_1
XFILLER_7_293 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XTAP_598 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_587 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_197 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2216_ clknet_1_0__leaf_ref_in _0017_ _0242_ vss vss vdd vdd d5.fll_core.counter2.count\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_2147_ clknet_4_3_0_clk_in _0410_ _0173_ vss vss vdd vdd d2.t_load\[55\] sky130_fd_sc_hd__dfrtp_1
XFILLER_53_156 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1029_ d5.fll_core.tmp\[3\] d5.fll_core.tmp\[2\] vss vss vdd vdd _0824_ sky130_fd_sc_hd__or2_1
XFILLER_34_392 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2078_ clknet_4_4_0_clk_in _0342_ _0107_ vss vss vdd vdd d2.r_reg\[86\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_47 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_134 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_164 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_326 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_348 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_40_351 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_263 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1380_ _0528_ vss vss vdd vdd _0338_ sky130_fd_sc_hd__clkbuf_1
X_2001_ clknet_4_6_0_clk_in _0265_ _0030_ vss vss vdd vdd d2.r_reg\[9\] sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_12_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_12_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_23_329 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_23_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_31_384 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1716_ d5.fll_core.counter2.count\[6\] _0744_ vss vss vdd vdd _0746_ sky130_fd_sc_hd__and2_1
X_1647_ _0710_ vss vss vdd vdd net7 sky130_fd_sc_hd__clkbuf_1
X_1578_ _0664_ d2.r_reg\[20\] _0662_ vss vss vdd vdd _0665_ sky130_fd_sc_hd__mux2_1
XTAP_384 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_395 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_189 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_13 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_24 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_35 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_46 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_148 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XPHY_79 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_68 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_57 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_25_79 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_25_68 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_42 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_57_270 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_145 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1501_ _0611_ d2.r_reg\[44\] _0596_ vss vss vdd vdd _0612_ sky130_fd_sc_hd__mux2_1
X_1432_ _0497_ vss vss vdd vdd _0564_ sky130_fd_sc_hd__clkbuf_4
X_1363_ _0516_ d2.r_reg\[87\] _0508_ vss vss vdd vdd _0517_ sky130_fd_sc_hd__mux2_1
X_1294_ d2.t_load\[18\] d2.r_reg\[18\] _0467_ vss vss vdd vdd _0475_ sky130_fd_sc_hd__mux2_1
XFILLER_11_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_229 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_170 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_295 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_54_284 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_39_281 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_10_343 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_10_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_37_218 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_60_221 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1981_ _0779_ vss vss vdd vdd _0245_ sky130_fd_sc_hd__inv_2
XFILLER_13_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_163 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_93 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1346_ d2.r_reg\[93\] net42 _0498_ vss vss vdd vdd _0505_ sky130_fd_sc_hd__mux2_1
X_1415_ _0551_ d2.r_reg\[71\] _0552_ vss vss vdd vdd _0553_ sky130_fd_sc_hd__mux2_1
X_1277_ d2.t_load\[26\] d2.r_reg\[26\] _0979_ vss vss vdd vdd _0466_ sky130_fd_sc_hd__mux2_1
XFILLER_36_251 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_59_332 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_99 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_47_44 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_262 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_229 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_8_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_6_177 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1200_ _0948_ vss vss vdd vdd _0418_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2180_ clknet_4_5_0_clk_in _0443_ _0206_ vss vss vdd vdd net38 sky130_fd_sc_hd__dfrtp_1
XFILLER_65_368 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1062_ d5.fll_core.tmp\[7\] d5.fll_core.tmp\[6\] d5.fll_core.tmp\[5\] d5.fll_core.tmp\[4\]
+ vss vss vdd vdd _0856_ sky130_fd_sc_hd__and4_1
X_1131_ _0911_ vss vss vdd vdd _0912_ sky130_fd_sc_hd__buf_4
XFILLER_18_295 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1964_ _0778_ vss vss vdd vdd _0229_ sky130_fd_sc_hd__inv_2
X_1895_ _0771_ vss vss vdd vdd _0167_ sky130_fd_sc_hd__inv_2
XFILLER_33_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xclkbuf_4_0_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_0_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_0_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1329_ d2.t_load\[2\] d2.r_reg\[2\] _0490_ vss vss vdd vdd _0494_ sky130_fd_sc_hd__mux2_1
XFILLER_33_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_24_298 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_24_265 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_24_232 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_58_98 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_3_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_243 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_30_224 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_15_254 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1680_ d2.t_load\[64\] d2.t_load\[40\] d2.t_load\[44\] vss vss vdd vdd _0727_ sky130_fd_sc_hd__mux2_1
XFILLER_65_143 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_65_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1114_ d5.fll_core.tmp\[2\] _0817_ _0899_ vss vss vdd vdd _0900_ sky130_fd_sc_hd__a21oi_1
XFILLER_24_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2163_ clknet_4_2_0_clk_in _0426_ _0189_ vss vss vdd vdd net21 sky130_fd_sc_hd__dfrtp_1
X_1045_ d5.fll_core.counter1.count\[1\] vss vss vdd vdd _0840_ sky130_fd_sc_hd__inv_2
XFILLER_0_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2094_ clknet_4_7_0_clk_in _0357_ _0120_ vss vss vdd vdd d2.t_load\[2\] sky130_fd_sc_hd__dfrtp_1
X_1878_ _0770_ vss vss vdd vdd _0151_ sky130_fd_sc_hd__inv_2
X_1947_ _0776_ vss vss vdd vdd _0214_ sky130_fd_sc_hd__inv_2
XFILLER_9_81 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_154 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_52_382 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_12_268 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_5_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_62_168 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_47_198 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_165 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1663_ _0718_ vss vss vdd vdd d5.mux01.out\[7\] sky130_fd_sc_hd__clkbuf_1
X_1801_ _0759_ vss vss vdd vdd _0088_ sky130_fd_sc_hd__inv_2
X_1732_ _0752_ vss vss vdd vdd _0026_ sky130_fd_sc_hd__inv_2
XTAP_566 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_500 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1594_ _0675_ d2.r_reg\[15\] _0662_ vss vss vdd vdd _0676_ sky130_fd_sc_hd__mux2_1
XTAP_599 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_577 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_135 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2146_ clknet_4_6_0_clk_in _0409_ _0172_ vss vss vdd vdd d2.t_load\[54\] sky130_fd_sc_hd__dfrtp_1
X_2215_ clknet_1_0__leaf_ref_in _0016_ _0241_ vss vss vdd vdd d5.fll_core.counter2.count\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_2077_ clknet_4_1_0_clk_in _0341_ _0106_ vss vss vdd vdd d2.r_reg\[85\] sky130_fd_sc_hd__dfrtp_1
XFILLER_19_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_61_190 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1028_ d5.fll_core.tmp\[0\] _0821_ _0822_ vss vss vdd vdd _0823_ sky130_fd_sc_hd__a21bo_1
XFILLER_41_308 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_14_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_29_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_102 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_187 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_371 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_360 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_4_253 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_35_124 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2000_ clknet_4_6_0_clk_in _0264_ _0029_ vss vss vdd vdd d2.r_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_157 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1646_ d5.fll_core.corner_tmp\[2\] d2.t_load\[32\] d2.t_load\[33\] vss vss vdd vdd
+ _0710_ sky130_fd_sc_hd__mux2_1
X_1715_ _0744_ _0745_ vss vss vdd vdd _0016_ sky130_fd_sc_hd__nor2_1
X_1577_ d2.r_reg\[21\] d2.t_load\[20\] _0652_ vss vss vdd vdd _0664_ sky130_fd_sc_hd__mux2_1
XTAP_396 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2129_ clknet_4_10_0_clk_in _0392_ _0155_ vss vss vdd vdd d2.t_load\[37\] sky130_fd_sc_hd__dfrtp_1
XPHY_69 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_58 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_47 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_14 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_25 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_36 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_41_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_34_190 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_1_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_54 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_66_10 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_17_113 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_124 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_32_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_17_157 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1500_ d2.r_reg\[45\] d2.t_load\[44\] _0608_ vss vss vdd vdd _0611_ sky130_fd_sc_hd__mux2_1
XFILLER_40_182 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1293_ _0474_ vss vss vdd vdd _0374_ sky130_fd_sc_hd__clkbuf_1
X_1431_ _0563_ vss vss vdd vdd _0322_ sky130_fd_sc_hd__clkbuf_1
X_1362_ d2.r_reg\[88\] net37 _0498_ vss vss vdd vdd _0516_ sky130_fd_sc_hd__mux2_1
XFILLER_48_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_23_127 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_11_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1629_ _0699_ vss vss vdd vdd _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_230 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_208 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_171 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_160 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_274 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_14_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_10_355 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_10_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_60_277 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_60_244 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1980_ _0779_ vss vss vdd vdd _0244_ sky130_fd_sc_hd__inv_2
XFILLER_13_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_54_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1276_ _0465_ vss vss vdd vdd _0382_ sky130_fd_sc_hd__clkbuf_1
X_1414_ _0478_ vss vss vdd vdd _0552_ sky130_fd_sc_hd__clkbuf_4
X_1345_ _0504_ vss vss vdd vdd _0349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_233 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_51_222 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_36_296 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_0_8 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_27_241 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_27_230 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_141 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_189 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_65_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1130_ net1 vss vss vdd vdd _0911_ sky130_fd_sc_hd__buf_4
X_1061_ _0832_ _0824_ _0852_ vss vss vdd vdd _0855_ sky130_fd_sc_hd__or3b_1
XFILLER_33_244 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_18_230 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1963_ _0778_ vss vss vdd vdd _0228_ sky130_fd_sc_hd__inv_2
X_1894_ _0771_ vss vss vdd vdd _0166_ sky130_fd_sc_hd__inv_2
X_1259_ d2.t_load\[35\] d2.r_reg\[35\] _0979_ vss vss vdd vdd _0980_ sky130_fd_sc_hd__mux2_1
XFILLER_56_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_17_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1328_ _0493_ vss vss vdd vdd _0358_ sky130_fd_sc_hd__clkbuf_1
XFILLER_47_303 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_30_203 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_15_233 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_15_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_30_258 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_65_188 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_65_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_53_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1044_ d5.fll_core.counter1.count\[2\] vss vss vdd vdd _0839_ sky130_fd_sc_hd__inv_2
X_1113_ _0820_ _0823_ vss vss vdd vdd _0899_ sky130_fd_sc_hd__and2_1
XFILLER_38_369 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2162_ clknet_4_2_0_clk_in _0425_ _0188_ vss vss vdd vdd net20 sky130_fd_sc_hd__dfrtp_1
X_2093_ clknet_4_5_0_clk_in _0356_ _0119_ vss vss vdd vdd d2.t_load\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_17_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_61_361 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_391 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_21_247 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1877_ _0757_ vss vss vdd vdd _0770_ sky130_fd_sc_hd__buf_4
XFILLER_9_93 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1946_ _0776_ vss vss vdd vdd _0213_ sky130_fd_sc_hd__inv_2
XFILLER_56_122 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_29_303 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_52_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_44_306 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_37_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_62_158 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1800_ _0759_ vss vss vdd vdd _0087_ sky130_fd_sc_hd__inv_2
X_1662_ d5.fll_core.tmp\[7\] d2.t_load\[54\] _0954_ vss vss vdd vdd _0718_ sky130_fd_sc_hd__mux2_1
X_1731_ _0752_ vss vss vdd vdd _0025_ sky130_fd_sc_hd__inv_2
XTAP_589 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_578 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_501 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1593_ d2.r_reg\[16\] d2.t_load\[15\] _0674_ vss vss vdd vdd _0675_ sky130_fd_sc_hd__mux2_1
XFILLER_38_111 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2214_ clknet_1_0__leaf_ref_in _0015_ _0240_ vss vss vdd vdd d5.fll_core.counter2.count\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_169 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1027_ _0810_ _0814_ d5.fll_core.tmp\[1\] vss vss vdd vdd _0822_ sky130_fd_sc_hd__o21ai_1
XFILLER_38_133 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2145_ clknet_4_6_0_clk_in _0408_ _0171_ vss vss vdd vdd d2.t_load\[53\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_317 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2076_ clknet_4_1_0_clk_in _0340_ _0105_ vss vss vdd vdd d2.r_reg\[84\] sky130_fd_sc_hd__dfrtp_1
X_1929_ _0774_ vss vss vdd vdd _0198_ sky130_fd_sc_hd__inv_2
XFILLER_14_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_30_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_39_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_29_133 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_52_180 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_320 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_32_309 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_25_383 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_221 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_4_287 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_81 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_35_169 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_29_90 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_353 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_31_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_361 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1645_ _0709_ vss vss vdd vdd net6 sky130_fd_sc_hd__clkbuf_1
X_1576_ _0663_ vss vss vdd vdd _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_83 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1714_ d5.fll_core.counter2.count\[4\] _0742_ d5.fll_core.counter2.count\[5\] vss
+ vss vdd vdd _0745_ sky130_fd_sc_hd__a21oi_1
XFILLER_66_272 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_397 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2128_ clknet_4_10_0_clk_in _0391_ _0154_ vss vss vdd vdd d2.t_load\[36\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_106 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XPHY_59 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_2059_ clknet_4_2_0_clk_in _0323_ _0088_ vss vss vdd vdd d2.r_reg\[67\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_125 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_25_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_48 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_15 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_26 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_14_309 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XPHY_37 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_22_320 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_41_69 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_1_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_66_22 vss vss vdd vdd sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f_ref_in clknet_0_ref_in vss vss vdd vdd clknet_1_1__leaf_ref_in sky130_fd_sc_hd__clkbuf_16
XFILLER_17_136 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_17_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_40_194 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_40_150 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_32_117 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_180 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_342 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_386 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1430_ _0562_ d2.r_reg\[66\] _0552_ vss vss vdd vdd _0563_ sky130_fd_sc_hd__mux2_1
X_1292_ d2.t_load\[19\] d2.r_reg\[19\] _0467_ vss vss vdd vdd _0474_ sky130_fd_sc_hd__mux2_1
XFILLER_48_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1361_ _0515_ vss vss vdd vdd _0344_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_161 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_11_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1559_ _0651_ vss vss vdd vdd _0282_ sky130_fd_sc_hd__clkbuf_1
XTAP_150 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1628_ _0698_ d2.r_reg\[4\] _0684_ vss vss vdd vdd _0699_ sky130_fd_sc_hd__mux2_1
XFILLER_54_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_36_69 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_172 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_172 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_220 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_9_143 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_109 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1413_ d2.r_reg\[72\] net21 _0542_ vss vss vdd vdd _0551_ sky130_fd_sc_hd__mux2_1
X_1275_ d2.t_load\[27\] d2.r_reg\[27\] _0979_ vss vss vdd vdd _0465_ sky130_fd_sc_hd__mux2_1
XFILLER_36_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_3_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1344_ _0503_ d2.r_reg\[93\] _0490_ vss vss vdd vdd _0504_ sky130_fd_sc_hd__mux2_1
XFILLER_51_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_51_201 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_3_319 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_22_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_22_49 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_59_389 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_59_301 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_45 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_47_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_6_102 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_8_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_363 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_10_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_65_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1060_ d5.fll_core.tmp\[9\] d5.fll_core.tmp\[8\] d5.fll_core.tmp\[1\] d5.fll_core.tmp\[0\]
+ vss vss vdd vdd _0854_ sky130_fd_sc_hd__or4b_1
X_1962_ _0778_ vss vss vdd vdd _0227_ sky130_fd_sc_hd__inv_2
XFILLER_33_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_18_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_18_264 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1893_ _0771_ vss vss vdd vdd _0165_ sky130_fd_sc_hd__inv_2
XFILLER_56_304 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1258_ _0911_ vss vss vdd vdd _0979_ sky130_fd_sc_hd__clkbuf_4
X_1189_ _0942_ vss vss vdd vdd _0423_ sky130_fd_sc_hd__clkbuf_1
XFILLER_17_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1327_ d2.t_load\[3\] d2.r_reg\[3\] _0490_ vss vss vdd vdd _0493_ sky130_fd_sc_hd__mux2_1
XFILLER_24_289 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_59_142 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_47_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1043_ d5.fll_core.counter1.count\[3\] vss vss vdd vdd _0838_ sky130_fd_sc_hd__inv_2
X_1112_ _0898_ vss vss vdd vdd _0456_ sky130_fd_sc_hd__clkbuf_1
X_2161_ clknet_4_8_0_clk_in _0424_ _0187_ vss vss vdd vdd net19 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_63 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_0_85 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2092_ clknet_4_5_0_clk_in _0355_ _0118_ vss vss vdd vdd d2.t_load\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_373 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1945_ _0776_ vss vss vdd vdd _0212_ sky130_fd_sc_hd__inv_2
X_1876_ _0769_ vss vss vdd vdd _0150_ sky130_fd_sc_hd__inv_2
XFILLER_29_337 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_189 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_52_340 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_292 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_126 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_362 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_351 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1661_ _0717_ vss vss vdd vdd d5.mux01.out\[6\] sky130_fd_sc_hd__clkbuf_1
X_1592_ net2 vss vss vdd vdd _0674_ sky130_fd_sc_hd__clkbuf_4
XFILLER_11_281 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1730_ _0752_ vss vss vdd vdd _0024_ sky130_fd_sc_hd__inv_2
XTAP_579 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_568 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2144_ clknet_4_12_0_clk_in _0407_ _0170_ vss vss vdd vdd d2.t_load\[52\] sky130_fd_sc_hd__dfrtp_1
X_2213_ clknet_1_0__leaf_ref_in _0014_ _0239_ vss vss vdd vdd d5.fll_core.counter2.count\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_53_148 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1026_ d5.fll_core.tmp\[1\] _0810_ _0814_ vss vss vdd vdd _0821_ sky130_fd_sc_hd__or3_1
XFILLER_34_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_34_351 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_2075_ clknet_4_0_0_clk_in _0339_ _0104_ vss vss vdd vdd d2.r_reg\[83\] sky130_fd_sc_hd__dfrtp_1
X_1859_ _0768_ vss vss vdd vdd _0134_ sky130_fd_sc_hd__inv_2
XFILLER_30_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1928_ _0774_ vss vss vdd vdd _0197_ sky130_fd_sc_hd__inv_2
XFILLER_55_57 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_44_126 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_29_123 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_365 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_233 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_50_118 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_35_137 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1713_ d5.fll_core.counter2.count\[4\] d5.fll_core.counter2.count\[5\] _0742_ vss
+ vss vdd vdd _0744_ sky130_fd_sc_hd__and3_1
X_1644_ d5.fll_core.corner_tmp\[1\] d2.t_load\[31\] d2.t_load\[33\] vss vss vdd vdd
+ _0709_ sky130_fd_sc_hd__mux2_1
X_1575_ _0661_ d2.r_reg\[21\] _0662_ vss vss vdd vdd _0663_ sky130_fd_sc_hd__mux2_1
XTAP_332 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2127_ clknet_4_10_0_clk_in _0390_ _0153_ vss vss vdd vdd d2.t_load\[35\] sky130_fd_sc_hd__dfrtp_1
XTAP_398 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_137 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_26_104 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1009_ d2.t_load\[21\] d5.fll_core.counter1.count\[1\] vss vss vdd vdd _0804_ sky130_fd_sc_hd__and2b_1
X_2058_ clknet_4_2_0_clk_in _0322_ _0087_ vss vss vdd vdd d2.r_reg\[66\] sky130_fd_sc_hd__dfrtp_1
XFILLER_26_148 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_49 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_16 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_27 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_38 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_22_365 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_41_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_49_218 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_1_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_1_236 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_78 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_17_104 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_9_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_354 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_15_71 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1360_ _0514_ d2.r_reg\[88\] _0508_ vss vss vdd vdd _0515_ sky130_fd_sc_hd__mux2_1
X_1291_ _0473_ vss vss vdd vdd _0375_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_298 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_31_195 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1558_ _0650_ d2.r_reg\[26\] _0640_ vss vss vdd vdd _0651_ sky130_fd_sc_hd__mux2_1
X_1489_ _0603_ vss vss vdd vdd _0304_ sky130_fd_sc_hd__clkbuf_1
XTAP_173 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_140 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1627_ d2.r_reg\[5\] d2.t_load\[4\] _0497_ vss vss vdd vdd _0698_ sky130_fd_sc_hd__mux2_1
XFILLER_39_240 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_195 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_118 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_184 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_7_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_26_81 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1412_ _0550_ vss vss vdd vdd _0328_ sky130_fd_sc_hd__clkbuf_1
X_1343_ d2.r_reg\[94\] net43 _0498_ vss vss vdd vdd _0503_ sky130_fd_sc_hd__mux2_1
X_1274_ _0464_ vss vss vdd vdd _0383_ sky130_fd_sc_hd__clkbuf_1
XFILLER_36_265 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_36_243 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_51_257 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_0989_ d2.t_load\[28\] _0782_ vss vss vdd vdd _0784_ sky130_fd_sc_hd__nand2_1
XFILLER_47_69 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_63_57 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_42_202 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_349 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_37_91 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_18_221 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1961_ _0778_ vss vss vdd vdd _0226_ sky130_fd_sc_hd__inv_2
X_1892_ _0771_ vss vss vdd vdd _0164_ sky130_fd_sc_hd__inv_2
X_1326_ _0492_ vss vss vdd vdd _0359_ sky130_fd_sc_hd__clkbuf_1
X_1257_ _0978_ vss vss vdd vdd _0391_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_390 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1188_ net18 d2.r_reg\[68\] _0934_ vss vss vdd vdd _0942_ sky130_fd_sc_hd__mux2_1
XFILLER_24_246 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_17_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_47_349 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_47_327 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2160_ clknet_4_8_0_clk_in _0423_ _0186_ vss vss vdd vdd net18 sky130_fd_sc_hd__dfrtp_1
X_1111_ d5.fll_core.tmp\[4\] _0897_ _0881_ vss vss vdd vdd _0898_ sky130_fd_sc_hd__mux2_1
X_1042_ _0835_ _0836_ vss vss vdd vdd _0837_ sky130_fd_sc_hd__xnor2_1
X_2091_ clknet_1_0__leaf_ref_in _0000_ _0117_ vss vss vdd vdd d5.fll_core.strobe sky130_fd_sc_hd__dfrtp_4
XFILLER_0_97 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_61_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1875_ _0769_ vss vss vdd vdd _0149_ sky130_fd_sc_hd__inv_2
Xclkbuf_4_15_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_15_0_clk_in sky130_fd_sc_hd__clkbuf_8
XFILLER_9_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1944_ _0776_ vss vss vdd vdd _0211_ sky130_fd_sc_hd__inv_2
XFILLER_21_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_56_179 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1309_ _0483_ vss vss vdd vdd _0367_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_44_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_8_209 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_113 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_28_360 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_11_293 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_525 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1591_ _0673_ vss vss vdd vdd _0272_ sky130_fd_sc_hd__clkbuf_1
X_1660_ d5.fll_core.tmp\[6\] d2.t_load\[53\] _0954_ vss vss vdd vdd _0717_ sky130_fd_sc_hd__mux2_1
XTAP_569 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2143_ clknet_4_12_0_clk_in _0406_ _0169_ vss vss vdd vdd d2.t_load\[51\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_146 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2212_ clknet_1_0__leaf_ref_in _0013_ _0238_ vss vss vdd vdd d5.fll_core.counter2.count\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_1025_ d5.fll_core.tmp\[2\] _0815_ vss vss vdd vdd _0820_ sky130_fd_sc_hd__xnor2_1
X_2074_ clknet_4_0_0_clk_in _0338_ _0103_ vss vss vdd vdd d2.r_reg\[82\] sky130_fd_sc_hd__dfrtp_1
XFILLER_14_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1858_ _0768_ vss vss vdd vdd _0133_ sky130_fd_sc_hd__inv_2
X_1927_ _0774_ vss vss vdd vdd _0196_ sky130_fd_sc_hd__inv_2
XFILLER_39_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1789_ _0758_ vss vss vdd vdd _0077_ sky130_fd_sc_hd__inv_2
XFILLER_55_69 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_44_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_29_113 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_245 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_29_70 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_35_105 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_16_341 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1643_ _0708_ vss vss vdd vdd net5 sky130_fd_sc_hd__clkbuf_1
XANTENNA_1 d5.fll_core.tmp\[9\] vss vss vdd vdd sky130_fd_sc_hd__diode_2
X_1712_ d5.fll_core.counter2.count\[4\] _0742_ vss vss vdd vdd _0015_ sky130_fd_sc_hd__xor2_1
XFILLER_6_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1574_ _0478_ vss vss vdd vdd _0662_ sky130_fd_sc_hd__clkbuf_4
XTAP_366 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_300 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2126_ clknet_4_10_0_clk_in _0389_ _0152_ vss vss vdd vdd d2.t_load\[34\] sky130_fd_sc_hd__dfrtp_1
XTAP_399 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2057_ clknet_4_8_0_clk_in _0321_ _0086_ vss vss vdd vdd d2.r_reg\[65\] sky130_fd_sc_hd__dfrtp_1
XTAP_377 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_17 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_28 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1008_ d5.fll_core.counter1.count\[1\] d2.t_load\[21\] vss vss vdd vdd _0803_ sky130_fd_sc_hd__or2b_1
XFILLER_41_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XPHY_39 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_22_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_66_57 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_57_241 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_57_230 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_40_174 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_40_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_9_337 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_366 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_15_61 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1290_ d2.t_load\[20\] d2.r_reg\[20\] _0467_ vss vss vdd vdd _0473_ sky130_fd_sc_hd__mux2_1
XFILLER_0_292 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_23_108 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xclkbuf_4_3_0_clk_in clknet_0_clk_in vss vss vdd vdd clknet_4_3_0_clk_in sky130_fd_sc_hd__clkbuf_8
X_1626_ _0697_ vss vss vdd vdd _0261_ sky130_fd_sc_hd__clkbuf_1
X_1557_ d2.r_reg\[27\] d2.t_load\[26\] _0630_ vss vss vdd vdd _0650_ sky130_fd_sc_hd__mux2_1
X_1488_ _0602_ d2.r_reg\[48\] _0596_ vss vss vdd vdd _0603_ sky130_fd_sc_hd__mux2_1
XTAP_174 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_244 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_52_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_2109_ clknet_4_13_0_clk_in _0372_ _0135_ vss vss vdd vdd d2.t_load\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_6_307 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_22_130 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_141 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_13_130 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_9_156 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_167 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1273_ d2.t_load\[28\] d2.r_reg\[28\] _0979_ vss vss vdd vdd _0464_ sky130_fd_sc_hd__mux2_1
X_1411_ _0549_ d2.r_reg\[72\] _0530_ vss vss vdd vdd _0550_ sky130_fd_sc_hd__mux2_1
X_1342_ _0502_ vss vss vdd vdd _0350_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_225 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_51_214 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_36_233 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_0988_ d2.t_load\[29\] _0780_ _0782_ d2.t_load\[28\] vss vss vdd vdd _0783_ sky130_fd_sc_hd__o22ai_1
Xclkbuf_0_ref_in ref_in vss vss vdd vdd clknet_0_ref_in sky130_fd_sc_hd__clkbuf_16
XFILLER_22_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1609_ d2.r_reg\[11\] d2.t_load\[10\] _0674_ vss vss vdd vdd _0686_ sky130_fd_sc_hd__mux2_1
XFILLER_59_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_314 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_27_222 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_258 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_2_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_321 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_33_236 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_33_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_18_244 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_18_288 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1891_ _0771_ vss vss vdd vdd _0163_ sky130_fd_sc_hd__inv_2
X_1960_ d5.fll_core.counter_reset vss vss vdd vdd _0778_ sky130_fd_sc_hd__buf_4
XFILLER_52_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1256_ d2.t_load\[36\] d2.r_reg\[36\] _0968_ vss vss vdd vdd _0978_ sky130_fd_sc_hd__mux2_1
X_1325_ d2.t_load\[4\] d2.r_reg\[4\] _0490_ vss vss vdd vdd _0492_ sky130_fd_sc_hd__mux2_1
X_1187_ _0941_ vss vss vdd vdd _0424_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_291 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_155 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_62_309 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_59_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_15_225 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_65_136 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_2090_ clknet_1_1__leaf_ref_in _0354_ vss vss vdd vdd d5.fll_core.corner_tmp\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_1110_ _0825_ _0827_ vss vss vdd vdd _0897_ sky130_fd_sc_hd__xor2_1
XFILLER_65_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_64_90 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_61_331 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1041_ d5.fll_core.tmp\[9\] _0816_ vss vss vdd vdd _0836_ sky130_fd_sc_hd__xor2_1
XFILLER_21_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1874_ _0769_ vss vss vdd vdd _0148_ sky130_fd_sc_hd__inv_2
X_1943_ _0750_ vss vss vdd vdd _0776_ sky130_fd_sc_hd__buf_4
X_1239_ _0969_ vss vss vdd vdd _0400_ sky130_fd_sc_hd__clkbuf_1
XFILLER_44_309 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_37_372 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1308_ d2.t_load\[12\] d2.r_reg\[12\] _0479_ vss vss vdd vdd _0483_ sky130_fd_sc_hd__mux2_1
XFILLER_44_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_250 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_47_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_62_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_47_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_28_372 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_11_272 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XTAP_548 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1590_ _0672_ d2.r_reg\[16\] _0662_ vss vss vdd vdd _0673_ sky130_fd_sc_hd__mux2_1
XTAP_559 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_1024_ d5.fll_core.tmp\[3\] _0815_ vss vss vdd vdd _0819_ sky130_fd_sc_hd__xnor2_1
X_2142_ clknet_4_12_0_clk_in _0405_ _0168_ vss vss vdd vdd d2.t_load\[50\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_125 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_26_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2211_ clknet_1_0__leaf_ref_in _0012_ _0237_ vss vss vdd vdd d5.fll_core.counter2.count\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_2073_ clknet_4_1_0_clk_in _0337_ _0102_ vss vss vdd vdd d2.r_reg\[81\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_46_191 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1857_ _0768_ vss vss vdd vdd _0132_ sky130_fd_sc_hd__inv_2
XFILLER_30_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1926_ _0774_ vss vss vdd vdd _0195_ sky130_fd_sc_hd__inv_2
X_1788_ _0758_ vss vss vdd vdd _0076_ sky130_fd_sc_hd__inv_2
XFILLER_39_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_29_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_55_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_29_169 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_364 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_25_342 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_334 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_20_73 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_31_334 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_16_353 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1642_ d5.fll_core.corner_tmp\[0\] d2.t_load\[30\] d2.t_load\[33\] vss vss vdd vdd
+ _0708_ sky130_fd_sc_hd__mux2_1
XFILLER_61_91 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1711_ _0742_ _0743_ vss vss vdd vdd _0014_ sky130_fd_sc_hd__nor2_1
XANTENNA_2 net36 vss vss vdd vdd sky130_fd_sc_hd__diode_2
XFILLER_6_20 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_53 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_220 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1573_ d2.r_reg\[22\] d2.t_load\[21\] _0652_ vss vss vdd vdd _0661_ sky130_fd_sc_hd__mux2_1
XTAP_389 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_97 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_301 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_66_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_66_242 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_2125_ clknet_4_11_0_clk_in _0388_ _0151_ vss vss vdd vdd d2.t_load\[33\] sky130_fd_sc_hd__dfrtp_4
X_1007_ d5.fll_core.counter1.count\[0\] d2.t_load\[20\] vss vss vdd vdd _0802_ sky130_fd_sc_hd__or2b_1
X_2056_ clknet_4_8_0_clk_in _0320_ _0085_ vss vss vdd vdd d2.r_reg\[64\] sky130_fd_sc_hd__dfrtp_1
XPHY_18 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XPHY_29 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1909_ _0772_ vss vss vdd vdd _0180_ sky130_fd_sc_hd__inv_2
XFILLER_41_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_1_205 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_66_69 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_57_286 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_57_253 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_9_305 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_15_84 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_197 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_9_349 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_378 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_63_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_48_286 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_48_253 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_31_153 vss vss vdd vdd sky130_fd_sc_hd__decap_8
X_1556_ _0649_ vss vss vdd vdd _0283_ sky130_fd_sc_hd__clkbuf_1
X_1625_ _0696_ d2.r_reg\[5\] _0684_ vss vss vdd vdd _0697_ sky130_fd_sc_hd__mux2_1
XFILLER_54_212 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1487_ d2.r_reg\[49\] d2.t_load\[48\] _0586_ vss vss vdd vdd _0602_ sky130_fd_sc_hd__mux2_1
XFILLER_39_275 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_175 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_234 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_52_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2039_ clknet_4_14_0_clk_in _0303_ _0068_ vss vss vdd vdd d2.r_reg\[47\] sky130_fd_sc_hd__dfrtp_1
X_2108_ clknet_4_13_0_clk_in _0371_ _0134_ vss vss vdd vdd d2.t_load\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_164 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_22_197 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_60_237 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_42_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1410_ d2.r_reg\[73\] net22 _0542_ vss vss vdd vdd _0549_ sky130_fd_sc_hd__mux2_1
X_1272_ _0463_ vss vss vdd vdd _0384_ sky130_fd_sc_hd__clkbuf_1
X_1341_ _0501_ d2.r_reg\[94\] _0490_ vss vss vdd vdd _0502_ sky130_fd_sc_hd__mux2_1
XFILLER_36_289 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_36_212 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_0987_ d5.fll_core.counter1.count\[8\] vss vss vdd vdd _0782_ sky130_fd_sc_hd__inv_2
XFILLER_59_337 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1539_ _0637_ d2.r_reg\[32\] _0618_ vss vss vdd vdd _0638_ sky130_fd_sc_hd__mux2_1
X_1608_ _0685_ vss vss vdd vdd _0267_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_59_359 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_50_292 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_42_226 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_134 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_12_85 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_12_96 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_333 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_58_392 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1890_ _0771_ vss vss vdd vdd _0162_ sky130_fd_sc_hd__inv_2
XFILLER_41_281 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_45_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_64_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_64_340 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1255_ _0977_ vss vss vdd vdd _0392_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_370 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1186_ net19 d2.r_reg\[69\] _0934_ vss vss vdd vdd _0941_ sky130_fd_sc_hd__mux2_1
X_1324_ _0491_ vss vss vdd vdd _0360_ sky130_fd_sc_hd__clkbuf_1
XFILLER_58_15 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_47_318 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_351 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_15_204 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_23_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_2_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_159 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_340 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_318 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1040_ _0818_ _0833_ _0834_ vss vss vdd vdd _0835_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_61_354 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_46_362 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_0_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1942_ _0775_ vss vss vdd vdd _0210_ sky130_fd_sc_hd__inv_2
X_1873_ _0769_ vss vss vdd vdd _0147_ sky130_fd_sc_hd__inv_2
XFILLER_29_307 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_28_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1238_ d2.t_load\[45\] d2.r_reg\[45\] _0968_ vss vss vdd vdd _0969_ sky130_fd_sc_hd__mux2_1
X_1307_ _0482_ vss vss vdd vdd _0368_ sky130_fd_sc_hd__clkbuf_1
X_1169_ net27 d2.r_reg\[77\] _0923_ vss vss vdd vdd _0932_ sky130_fd_sc_hd__mux2_1
XFILLER_52_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_52_354 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_73 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_50_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_7_255 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_11_262 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XTAP_549 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2210_ clknet_1_0__leaf_ref_in _0011_ _0236_ vss vss vdd vdd d5.fll_core.counter2.count\[0\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_46_181 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_2141_ clknet_4_9_0_clk_in _0404_ _0167_ vss vss vdd vdd d2.t_load\[49\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_115 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1023_ d5.fll_core.tmp\[8\] _0817_ vss vss vdd vdd _0818_ sky130_fd_sc_hd__or2_1
X_2072_ clknet_4_1_0_clk_in _0336_ _0101_ vss vss vdd vdd d2.r_reg\[80\] sky130_fd_sc_hd__dfrtp_1
XFILLER_61_173 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_34_365 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1925_ _0774_ vss vss vdd vdd _0194_ sky130_fd_sc_hd__inv_2
X_1856_ _0768_ vss vss vdd vdd _0131_ sky130_fd_sc_hd__inv_2
X_1787_ _0758_ vss vss vdd vdd _0075_ sky130_fd_sc_hd__inv_2
XFILLER_39_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_55_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_52_184 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_20_41 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_20_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_20_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_29_83 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_45_82 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_31_346 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_365 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1572_ _0660_ vss vss vdd vdd _0278_ sky130_fd_sc_hd__clkbuf_1
XFILLER_6_65 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1641_ _0707_ vss vss vdd vdd _0256_ sky130_fd_sc_hd__clkbuf_1
X_1710_ d5.fll_core.counter2.count\[3\] _0740_ vss vss vdd vdd _0743_ sky130_fd_sc_hd__nor2_1
X_2124_ clknet_4_11_0_clk_in _0387_ _0150_ vss vss vdd vdd d2.t_load\[32\] sky130_fd_sc_hd__dfrtp_1
XTAP_379 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_265 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1006_ _0796_ _0800_ _0797_ _0798_ vss vss vdd vdd _0801_ sky130_fd_sc_hd__and4_1
X_2055_ clknet_4_8_0_clk_in _0319_ _0084_ vss vss vdd vdd d2.r_reg\[63\] sky130_fd_sc_hd__dfrtp_1
XPHY_19 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_19_181 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1839_ _0766_ vss vss vdd vdd _0354_ sky130_fd_sc_hd__clkbuf_1
X_1908_ _0772_ vss vss vdd vdd _0179_ sky130_fd_sc_hd__inv_2
XFILLER_30_390 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_1_217 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_66_37 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_184 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xoutput5 net5 vss vss vdd vdd corner[0] sky130_fd_sc_hd__clkbuf_1
XFILLER_31_62 vss vss vdd vdd sky130_fd_sc_hd__decap_4
Xoutput40 net40 vss vss vdd vdd vbias3[3] sky130_fd_sc_hd__clkbuf_1
XFILLER_56_92 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_31_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_31_132 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_16_195 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_1555_ _0648_ d2.r_reg\[27\] _0640_ vss vss vdd vdd _0649_ sky130_fd_sc_hd__mux2_1
X_1624_ d2.r_reg\[6\] d2.t_load\[5\] _0497_ vss vss vdd vdd _0696_ sky130_fd_sc_hd__mux2_1
XFILLER_54_224 vss vss vdd vdd sky130_fd_sc_hd__decap_3
X_1486_ _0601_ vss vss vdd vdd _0305_ sky130_fd_sc_hd__clkbuf_1
X_2107_ clknet_4_13_0_clk_in _0370_ _0133_ vss vss vdd vdd d2.t_load\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_265 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_36_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XTAP_176 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2038_ clknet_4_14_0_clk_in _0302_ _0067_ vss vss vdd vdd d2.r_reg\[46\] sky130_fd_sc_hd__dfrtp_1
XFILLER_22_176 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_6_309 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_42_94 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_103 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_169 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_13_110 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_54_8 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_5_342 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1340_ d2.r_reg\[95\] net44 _0498_ vss vss vdd vdd _0501_ sky130_fd_sc_hd__mux2_1
X_1271_ d2.t_load\[29\] d2.r_reg\[29\] _0979_ vss vss vdd vdd _0463_ sky130_fd_sc_hd__mux2_1
XFILLER_3_55 vss vss vdd vdd sky130_fd_sc_hd__fill_1
X_0986_ d2.t_load\[29\] _0780_ vss vss vdd vdd _0781_ sky130_fd_sc_hd__nand2_1
X_1538_ d2.r_reg\[33\] d2.t_load\[32\] _0630_ vss vss vdd vdd _0637_ sky130_fd_sc_hd__mux2_1
X_1607_ _0683_ d2.r_reg\[11\] _0684_ vss vss vdd vdd _0685_ sky130_fd_sc_hd__mux2_1
X_1469_ _0589_ d2.r_reg\[54\] _0574_ vss vss vdd vdd _0590_ sky130_fd_sc_hd__mux2_1
XFILLER_63_27 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_27_279 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_50_271 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_10_146 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_5_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_345 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_6_139 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_12_53 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_2_389 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_33_205 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_53_82 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_38_3 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1323_ d2.t_load\[5\] d2.r_reg\[5\] _0490_ vss vss vdd vdd _0491_ sky130_fd_sc_hd__mux2_1
X_1254_ d2.t_load\[37\] d2.r_reg\[37\] _0968_ vss vss vdd vdd _0977_ sky130_fd_sc_hd__mux2_1
XFILLER_49_382 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1185_ _0940_ vss vss vdd vdd _0425_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_113 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_58_27 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_15_216 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_197 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_2_164 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_2_120 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_65_127 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_48_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_48_71 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_46_330 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_0_12 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_0_67 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1872_ _0769_ vss vss vdd vdd _0146_ sky130_fd_sc_hd__inv_2
X_1941_ _0775_ vss vss vdd vdd _0209_ sky130_fd_sc_hd__inv_2
XFILLER_56_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_56_116 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1306_ d2.t_load\[13\] d2.r_reg\[13\] _0479_ vss vss vdd vdd _0482_ sky130_fd_sc_hd__mux2_1
X_1237_ _0911_ vss vss vdd vdd _0968_ sky130_fd_sc_hd__clkbuf_4
XFILLER_44_29 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_37_385 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1099_ _0829_ _0888_ vss vss vdd vdd _0889_ sky130_fd_sc_hd__xnor2_1
X_1168_ _0931_ vss vss vdd vdd _0433_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_41 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_18_85 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_55_193 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_43_388 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_366 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_11_241 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_18_96 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_50_94 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_7_223 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_7_267 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_7_278 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XTAP_539 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ clknet_4_12_0_clk_in _0403_ _0166_ vss vss vdd vdd d2.t_load\[48\] sky130_fd_sc_hd__dfrtp_1
X_1022_ _0816_ vss vss vdd vdd _0817_ sky130_fd_sc_hd__clkinv_2
XFILLER_38_138 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_2071_ clknet_4_0_0_clk_in _0335_ _0100_ vss vss vdd vdd d2.r_reg\[79\] sky130_fd_sc_hd__dfrtp_1
X_1855_ _0757_ vss vss vdd vdd _0768_ sky130_fd_sc_hd__buf_4
XFILLER_34_388 vss vss vdd vdd sky130_fd_sc_hd__decap_4
X_1924_ _0774_ vss vss vdd vdd _0193_ sky130_fd_sc_hd__inv_2
X_1786_ _0758_ vss vss vdd vdd _0074_ sky130_fd_sc_hd__inv_2
XFILLER_55_39 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_25_300 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_52_141 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_40_369 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_40_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_40_314 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_37_182 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_333 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_20_20 vss vss vdd vdd sky130_fd_sc_hd__decap_8
XFILLER_29_51 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_4_259 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_28_160 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_185 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_43_163 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_377 vss vss vdd vdd sky130_ef_sc_hd__decap_12
X_1571_ _0659_ d2.r_reg\[22\] _0640_ vss vss vdd vdd _0660_ sky130_fd_sc_hd__mux2_1
XTAP_314 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_6_77 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1640_ _0706_ net17 _0911_ vss vss vdd vdd _0707_ sky130_fd_sc_hd__mux2_1
XTAP_303 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_211 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_2123_ clknet_4_11_0_clk_in _0386_ _0149_ vss vss vdd vdd d2.t_load\[31\] sky130_fd_sc_hd__dfrtp_1
XTAP_369 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1005_ d5.fll_core.counter1.count\[2\] d2.t_load\[22\] vss vss vdd vdd _0800_ sky130_fd_sc_hd__or2b_1
X_2054_ clknet_4_8_0_clk_in _0318_ _0083_ vss vss vdd vdd d2.r_reg\[62\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_141 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_19_193 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_22_314 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_22_325 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_22_358 vss vss vdd vdd sky130_fd_sc_hd__decap_6
X_1838_ _0816_ d5.fll_core.corner_tmp\[2\] _0763_ vss vss vdd vdd _0766_ sky130_fd_sc_hd__mux2_1
X_1907_ _0772_ vss vss vdd vdd _0178_ sky130_fd_sc_hd__inv_2
X_1769_ _0755_ vss vss vdd vdd _0060_ sky130_fd_sc_hd__inv_2
XFILLER_57_277 vss vss vdd vdd sky130_fd_sc_hd__decap_3
XFILLER_57_222 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_25_152 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_9_318 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_13_303 vss vss vdd vdd sky130_fd_sc_hd__decap_6
XFILLER_15_97 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_21_391 vss vss vdd vdd sky130_fd_sc_hd__fill_1
Xoutput6 net6 vss vss vdd vdd corner[1] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net41 vss vss vdd vdd vbias3[4] sky130_fd_sc_hd__clkbuf_1
Xoutput30 net30 vss vss vdd vdd vbias2[1] sky130_fd_sc_hd__clkbuf_1
XFILLER_48_233 vss vss vdd vdd sky130_fd_sc_hd__fill_1
XFILLER_63_247 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_63_225 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_56_82 vss vss vdd vdd sky130_fd_sc_hd__fill_2
XFILLER_16_130 vss vss vdd vdd sky130_fd_sc_hd__decap_4
XFILLER_16_141 vss vss vdd vdd sky130_ef_sc_hd__decap_12
XFILLER_31_166 vss vss vdd vdd sky130_fd_sc_hd__fill_2
X_1554_ d2.r_reg\[28\] d2.t_load\[27\] _0630_ vss vss vdd vdd _0648_ sky130_fd_sc_hd__mux2_1
X_1485_ _0600_ d2.r_reg\[49\] _0596_ vss vss vdd vdd _0601_ sky130_fd_sc_hd__mux2_1
X_1623_ _0695_ vss vss vdd vdd _0262_ sky130_fd_sc_hd__clkbuf_1
XTAP_166 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 vss vdd sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
