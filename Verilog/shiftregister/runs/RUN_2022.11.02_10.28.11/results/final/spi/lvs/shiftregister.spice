* NGSPICE file created from shiftregister.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

.subckt shiftregister VGND VPWR clk load r_load[0] r_load[10] r_load[11] r_load[12]
+ r_load[13] r_load[14] r_load[15] r_load[16] r_load[17] r_load[18] r_load[19] r_load[1]
+ r_load[20] r_load[21] r_load[22] r_load[23] r_load[24] r_load[25] r_load[26] r_load[27]
+ r_load[28] r_load[29] r_load[2] r_load[30] r_load[31] r_load[32] r_load[33] r_load[34]
+ r_load[35] r_load[36] r_load[37] r_load[38] r_load[39] r_load[3] r_load[40] r_load[41]
+ r_load[42] r_load[43] r_load[44] r_load[45] r_load[46] r_load[47] r_load[48] r_load[49]
+ r_load[4] r_load[50] r_load[51] r_load[52] r_load[53] r_load[54] r_load[55] r_load[56]
+ r_load[57] r_load[58] r_load[59] r_load[5] r_load[60] r_load[61] r_load[62] r_load[63]
+ r_load[64] r_load[65] r_load[66] r_load[67] r_load[68] r_load[69] r_load[6] r_load[70]
+ r_load[71] r_load[72] r_load[73] r_load[74] r_load[75] r_load[76] r_load[77] r_load[78]
+ r_load[79] r_load[7] r_load[80] r_load[81] r_load[82] r_load[83] r_load[84] r_load[85]
+ r_load[86] r_load[87] r_load[88] r_load[89] r_load[8] r_load[90] r_load[91] r_load[92]
+ r_load[93] r_load[94] r_load[95] r_load[96] r_load[97] r_load[98] r_load[99] r_load[9]
+ r_read[0] r_read[10] r_read[11] r_read[12] r_read[13] r_read[14] r_read[15] r_read[16]
+ r_read[17] r_read[18] r_read[19] r_read[1] r_read[20] r_read[21] r_read[22] r_read[23]
+ r_read[24] r_read[25] r_read[26] r_read[27] r_read[28] r_read[29] r_read[2] r_read[30]
+ r_read[31] r_read[32] r_read[33] r_read[34] r_read[35] r_read[36] r_read[37] r_read[38]
+ r_read[39] r_read[3] r_read[40] r_read[41] r_read[42] r_read[43] r_read[44] r_read[45]
+ r_read[46] r_read[47] r_read[48] r_read[49] r_read[4] r_read[50] r_read[51] r_read[52]
+ r_read[53] r_read[54] r_read[55] r_read[56] r_read[57] r_read[58] r_read[59] r_read[5]
+ r_read[60] r_read[61] r_read[62] r_read[63] r_read[64] r_read[65] r_read[66] r_read[67]
+ r_read[68] r_read[69] r_read[6] r_read[70] r_read[71] r_read[72] r_read[73] r_read[74]
+ r_read[75] r_read[76] r_read[77] r_read[78] r_read[79] r_read[7] r_read[80] r_read[81]
+ r_read[82] r_read[83] r_read[84] r_read[85] r_read[86] r_read[87] r_read[88] r_read[89]
+ r_read[8] r_read[90] r_read[91] r_read[92] r_read[93] r_read[94] r_read[95] r_read[96]
+ r_read[97] r_read[98] r_read[99] r_read[9] read reset s_in s_out
XFILLER_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1270_ _1699_/Q _1799_/Q _1270_/S VGND VGND VPWR VPWR _1271_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0985_ _1798_/Q input50/X _0994_/S VGND VGND VPWR VPWR _0985_/X sky130_fd_sc_hd__mux2_1
XFILLER_8_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1606_ _1606_/A VGND VGND VPWR VPWR _1606_/Y sky130_fd_sc_hd__inv_2
X_1537_ _1538_/A VGND VGND VPWR VPWR _1537_/Y sky130_fd_sc_hd__inv_2
XFILLER_47_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1399_ _1402_/A VGND VGND VPWR VPWR _1399_/Y sky130_fd_sc_hd__inv_2
X_1468_ _1470_/A VGND VGND VPWR VPWR _1468_/Y sky130_fd_sc_hd__inv_2
XFILLER_6_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1322_ _1676_/Q _1776_/Q _1326_/S VGND VGND VPWR VPWR _1323_/A sky130_fd_sc_hd__mux2_1
X_1253_ _1707_/Q _1807_/Q _1259_/S VGND VGND VPWR VPWR _1254_/A sky130_fd_sc_hd__mux2_1
X_1184_ _1738_/Q _1838_/Q _1192_/S VGND VGND VPWR VPWR _1185_/A sky130_fd_sc_hd__mux2_1
Xclkbuf_4_12_0_clk clkbuf_3_6_0_clk/X VGND VGND VPWR VPWR _1833_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_32_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0968_ _1803_/Q input55/X _0977_/S VGND VGND VPWR VPWR _0968_/X sky130_fd_sc_hd__mux2_1
X_0899_ _0898_/X _1822_/Q _0908_/S VGND VGND VPWR VPWR _0900_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0822_ _1084_/A VGND VGND VPWR VPWR _0893_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_1_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_4_3_0_clk/A sky130_fd_sc_hd__clkbuf_2
XFILLER_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1305_ _1305_/A VGND VGND VPWR VPWR _1684_/D sky130_fd_sc_hd__clkbuf_1
X_1236_ _1236_/A VGND VGND VPWR VPWR _1715_/D sky130_fd_sc_hd__clkbuf_1
X_1167_ _1167_/A VGND VGND VPWR VPWR _1745_/D sky130_fd_sc_hd__clkbuf_1
X_1098_ _1097_/X _1765_/Q _1101_/S VGND VGND VPWR VPWR _1099_/A sky130_fd_sc_hd__mux2_1
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1021_ _1788_/Q input39/X _1030_/S VGND VGND VPWR VPWR _1021_/X sky130_fd_sc_hd__mux2_1
X_1785_ _1793_/CLK _1785_/D _1572_/Y VGND VGND VPWR VPWR _1785_/Q sky130_fd_sc_hd__dfrtp_1
X_1219_ _1722_/Q _1822_/Q _1225_/S VGND VGND VPWR VPWR _1220_/A sky130_fd_sc_hd__mux2_1
XFILLER_29_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1570_ _1576_/A VGND VGND VPWR VPWR _1575_/A sky130_fd_sc_hd__buf_2
XANTENNA_5 input22/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1004_ _1793_/Q input44/X _1013_/S VGND VGND VPWR VPWR _1004_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1768_ _1768_/CLK _1768_/D _1550_/Y VGND VGND VPWR VPWR _1768_/Q sky130_fd_sc_hd__dfrtp_1
X_1837_ _1837_/CLK _1837_/D _1636_/Y VGND VGND VPWR VPWR _1837_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1699_ _1822_/CLK _1699_/D _1466_/Y VGND VGND VPWR VPWR _1699_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_1_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1622_ _1625_/A VGND VGND VPWR VPWR _1622_/Y sky130_fd_sc_hd__inv_2
XFILLER_31_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1553_ _1557_/A VGND VGND VPWR VPWR _1553_/Y sky130_fd_sc_hd__inv_2
X_1484_ _1488_/A VGND VGND VPWR VPWR _1484_/Y sky130_fd_sc_hd__inv_2
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0984_ _0984_/A VGND VGND VPWR VPWR _1798_/D sky130_fd_sc_hd__clkbuf_1
X_1536_ _1538_/A VGND VGND VPWR VPWR _1536_/Y sky130_fd_sc_hd__inv_2
XFILLER_8_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1605_ _1606_/A VGND VGND VPWR VPWR _1605_/Y sky130_fd_sc_hd__inv_2
X_1398_ _1402_/A VGND VGND VPWR VPWR _1398_/Y sky130_fd_sc_hd__inv_2
X_1467_ _1470_/A VGND VGND VPWR VPWR _1467_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1321_ _1321_/A VGND VGND VPWR VPWR _1677_/D sky130_fd_sc_hd__clkbuf_1
X_1252_ _1252_/A VGND VGND VPWR VPWR _1708_/D sky130_fd_sc_hd__clkbuf_1
X_1183_ _1216_/A VGND VGND VPWR VPWR _1192_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0967_ _0967_/A VGND VGND VPWR VPWR _1803_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1519_ _1519_/A VGND VGND VPWR VPWR _1519_/Y sky130_fd_sc_hd__inv_2
X_0898_ _1823_/Q input77/X _0907_/S VGND VGND VPWR VPWR _0898_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1166_ _1165_/X _1745_/Q _1169_/S VGND VGND VPWR VPWR _1167_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1304_ _1684_/Q _1784_/Q _1304_/S VGND VGND VPWR VPWR _1305_/A sky130_fd_sc_hd__mux2_1
X_1235_ _1715_/Q _1815_/Q _1237_/S VGND VGND VPWR VPWR _1236_/A sky130_fd_sc_hd__mux2_1
XFILLER_52_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1097_ _1766_/Q input15/X _1100_/S VGND VGND VPWR VPWR _1097_/X sky130_fd_sc_hd__mux2_1
XFILLER_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_11_0_clk clkbuf_3_5_0_clk/X VGND VGND VPWR VPWR _1763_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1020_ _1020_/A VGND VGND VPWR VPWR _1788_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_34_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1784_ _1790_/CLK _1784_/D _1571_/Y VGND VGND VPWR VPWR _1784_/Q sky130_fd_sc_hd__dfrtp_1
X_1149_ _1148_/X _1750_/Q _1152_/S VGND VGND VPWR VPWR _1150_/A sky130_fd_sc_hd__mux2_1
X_1218_ _1218_/A VGND VGND VPWR VPWR _1723_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_25_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_0_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_4_1_0_clk/A sky130_fd_sc_hd__clkbuf_2
XFILLER_16_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_6 input26/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1003_ _1003_/A VGND VGND VPWR VPWR _1793_/D sky130_fd_sc_hd__clkbuf_1
X_1767_ _1837_/CLK _1767_/D _1549_/Y VGND VGND VPWR VPWR _1767_/Q sky130_fd_sc_hd__dfrtp_1
X_1698_ _1803_/CLK _1698_/D _1464_/Y VGND VGND VPWR VPWR _1698_/Q sky130_fd_sc_hd__dfrtp_2
X_1836_ _1837_/CLK _1836_/D _1635_/Y VGND VGND VPWR VPWR _1836_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1621_ _1625_/A VGND VGND VPWR VPWR _1621_/Y sky130_fd_sc_hd__inv_2
X_1552_ _1576_/A VGND VGND VPWR VPWR _1557_/A sky130_fd_sc_hd__buf_2
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1483_ _1483_/A VGND VGND VPWR VPWR _1488_/A sky130_fd_sc_hd__buf_2
XFILLER_54_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1819_ _1822_/CLK _1819_/D _1615_/Y VGND VGND VPWR VPWR _1819_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0983_ _0981_/X _1798_/Q _0995_/S VGND VGND VPWR VPWR _0984_/A sky130_fd_sc_hd__mux2_1
XFILLER_8_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1535_ _1538_/A VGND VGND VPWR VPWR _1535_/Y sky130_fd_sc_hd__inv_2
X_1604_ _1606_/A VGND VGND VPWR VPWR _1604_/Y sky130_fd_sc_hd__inv_2
X_1397_ _1421_/A VGND VGND VPWR VPWR _1402_/A sky130_fd_sc_hd__buf_2
X_1466_ _1470_/A VGND VGND VPWR VPWR _1466_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1320_ _1677_/Q _1777_/Q _1326_/S VGND VGND VPWR VPWR _1321_/A sky130_fd_sc_hd__mux2_1
XFILLER_49_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1182_ _1182_/A VGND VGND VPWR VPWR _1739_/D sky130_fd_sc_hd__clkbuf_1
X_1251_ _1708_/Q _1808_/Q _1259_/S VGND VGND VPWR VPWR _1252_/A sky130_fd_sc_hd__mux2_1
Xoutput200 _1740_/Q VGND VGND VPWR VPWR r_load[96] sky130_fd_sc_hd__buf_2
X_0897_ _0897_/A VGND VGND VPWR VPWR _1823_/D sky130_fd_sc_hd__clkbuf_1
X_0966_ _0964_/X _1803_/Q _0978_/S VGND VGND VPWR VPWR _0967_/A sky130_fd_sc_hd__mux2_1
X_1518_ _1519_/A VGND VGND VPWR VPWR _1518_/Y sky130_fd_sc_hd__inv_2
X_1449_ _1451_/A VGND VGND VPWR VPWR _1449_/Y sky130_fd_sc_hd__inv_2
XFILLER_23_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1303_ _1303_/A VGND VGND VPWR VPWR _1685_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_49_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1165_ _1746_/Q input13/X _1168_/S VGND VGND VPWR VPWR _1165_/X sky130_fd_sc_hd__mux2_1
X_1096_ _1096_/A VGND VGND VPWR VPWR _1766_/D sky130_fd_sc_hd__clkbuf_1
X_1234_ _1234_/A VGND VGND VPWR VPWR _1716_/D sky130_fd_sc_hd__clkbuf_1
X_0949_ _0947_/X _1808_/Q _0961_/S VGND VGND VPWR VPWR _0950_/A sky130_fd_sc_hd__mux2_1
XFILLER_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1783_ _1790_/CLK _1783_/D _1569_/Y VGND VGND VPWR VPWR _1783_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1148_ _1751_/Q input68/X _1151_/S VGND VGND VPWR VPWR _1148_/X sky130_fd_sc_hd__mux2_1
XFILLER_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1217_ _1723_/Q _1823_/Q _1225_/S VGND VGND VPWR VPWR _1218_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1079_ _1078_/X _1770_/Q _1082_/S VGND VGND VPWR VPWR _1080_/A sky130_fd_sc_hd__mux2_1
XFILLER_28_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_7 input42/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1002_ _0999_/X _1793_/Q _1014_/S VGND VGND VPWR VPWR _1003_/A sky130_fd_sc_hd__mux2_1
XFILLER_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1835_ _1838_/CLK _1835_/D _1634_/Y VGND VGND VPWR VPWR _1835_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1766_ _1838_/CLK _1766_/D _1548_/Y VGND VGND VPWR VPWR _1766_/Q sky130_fd_sc_hd__dfrtp_1
X_1697_ _1798_/CLK _1697_/D _1463_/Y VGND VGND VPWR VPWR _1697_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_10_0_clk clkbuf_3_5_0_clk/X VGND VGND VPWR VPWR _1768_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_40_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput100 r_read[99] VGND VGND VPWR VPWR _0824_/A1 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1620_ _1638_/A VGND VGND VPWR VPWR _1625_/A sky130_fd_sc_hd__buf_2
X_1551_ _1613_/A VGND VGND VPWR VPWR _1576_/A sky130_fd_sc_hd__clkbuf_2
X_1482_ _1482_/A VGND VGND VPWR VPWR _1482_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1818_ _1818_/CLK _1818_/D _1612_/Y VGND VGND VPWR VPWR _1818_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_22_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1749_ _1768_/CLK _1749_/D _1528_/Y VGND VGND VPWR VPWR _1749_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0982_ _0982_/A VGND VGND VPWR VPWR _0995_/S sky130_fd_sc_hd__clkbuf_2
X_1534_ _1538_/A VGND VGND VPWR VPWR _1534_/Y sky130_fd_sc_hd__inv_2
X_1465_ _1483_/A VGND VGND VPWR VPWR _1470_/A sky130_fd_sc_hd__buf_2
X_1603_ _1606_/A VGND VGND VPWR VPWR _1603_/Y sky130_fd_sc_hd__inv_2
X_1396_ _1520_/A VGND VGND VPWR VPWR _1421_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_5_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1181_ _1739_/Q _1839_/Q _1181_/S VGND VGND VPWR VPWR _1182_/A sky130_fd_sc_hd__mux2_1
X_1250_ _1272_/A VGND VGND VPWR VPWR _1259_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput201 _1741_/Q VGND VGND VPWR VPWR r_load[97] sky130_fd_sc_hd__buf_2
X_0896_ _0894_/X _1823_/Q _0908_/S VGND VGND VPWR VPWR _0897_/A sky130_fd_sc_hd__mux2_1
X_0965_ _0982_/A VGND VGND VPWR VPWR _0978_/S sky130_fd_sc_hd__clkbuf_2
X_1517_ _1519_/A VGND VGND VPWR VPWR _1517_/Y sky130_fd_sc_hd__inv_2
X_1448_ _1451_/A VGND VGND VPWR VPWR _1448_/Y sky130_fd_sc_hd__inv_2
X_1379_ _1379_/A VGND VGND VPWR VPWR _1651_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1302_ _1685_/Q _1785_/Q _1304_/S VGND VGND VPWR VPWR _1303_/A sky130_fd_sc_hd__mux2_1
X_1233_ _1716_/Q _1816_/Q _1237_/S VGND VGND VPWR VPWR _1234_/A sky130_fd_sc_hd__mux2_1
XFILLER_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1164_ _1164_/A VGND VGND VPWR VPWR _1746_/D sky130_fd_sc_hd__clkbuf_1
X_1095_ _1094_/X _1766_/Q _1101_/S VGND VGND VPWR VPWR _1096_/A sky130_fd_sc_hd__mux2_1
X_0948_ _0982_/A VGND VGND VPWR VPWR _0961_/S sky130_fd_sc_hd__clkbuf_2
X_0879_ _0877_/X _1828_/Q _0891_/S VGND VGND VPWR VPWR _0880_/A sky130_fd_sc_hd__mux2_1
XFILLER_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1782_ _1790_/CLK _1782_/D _1568_/Y VGND VGND VPWR VPWR _1782_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1216_ _1216_/A VGND VGND VPWR VPWR _1225_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_52_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1147_ _1147_/A VGND VGND VPWR VPWR _1751_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1078_ _1771_/Q input20/X _1081_/S VGND VGND VPWR VPWR _1078_/X sky130_fd_sc_hd__mux2_1
XFILLER_20_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_8 input44/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1001_ _1069_/A VGND VGND VPWR VPWR _1014_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1765_ _1768_/CLK _1765_/D _1547_/Y VGND VGND VPWR VPWR _1765_/Q sky130_fd_sc_hd__dfrtp_1
X_1834_ _1838_/CLK _1834_/D _1633_/Y VGND VGND VPWR VPWR _1834_/Q sky130_fd_sc_hd__dfrtp_1
X_1696_ _1798_/CLK _1696_/D _1462_/Y VGND VGND VPWR VPWR _1696_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput101 r_read[9] VGND VGND VPWR VPWR _1138_/A1 sky130_fd_sc_hd__clkbuf_1
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1550_ _1550_/A VGND VGND VPWR VPWR _1550_/Y sky130_fd_sc_hd__inv_2
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1481_ _1482_/A VGND VGND VPWR VPWR _1481_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1748_ _1758_/CLK _1748_/D _1526_/Y VGND VGND VPWR VPWR _1748_/Q sky130_fd_sc_hd__dfrtp_1
X_1817_ _1817_/CLK _1817_/D _1611_/Y VGND VGND VPWR VPWR _1817_/Q sky130_fd_sc_hd__dfrtp_1
X_1679_ _1790_/CLK _1679_/D _1441_/Y VGND VGND VPWR VPWR _1679_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_26_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0981_ _1799_/Q input51/X _0994_/S VGND VGND VPWR VPWR _0981_/X sky130_fd_sc_hd__mux2_1
X_1602_ _1606_/A VGND VGND VPWR VPWR _1602_/Y sky130_fd_sc_hd__inv_2
XFILLER_8_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1533_ _1545_/A VGND VGND VPWR VPWR _1538_/A sky130_fd_sc_hd__buf_2
X_1464_ _1464_/A VGND VGND VPWR VPWR _1464_/Y sky130_fd_sc_hd__inv_2
X_1395_ _1613_/A VGND VGND VPWR VPWR _1520_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_50_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1180_ _1180_/A VGND VGND VPWR VPWR _1740_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0964_ _1804_/Q input56/X _0977_/S VGND VGND VPWR VPWR _0964_/X sky130_fd_sc_hd__mux2_1
Xoutput202 _1742_/Q VGND VGND VPWR VPWR r_load[98] sky130_fd_sc_hd__buf_2
X_1516_ _1519_/A VGND VGND VPWR VPWR _1516_/Y sky130_fd_sc_hd__inv_2
X_0895_ _0895_/A VGND VGND VPWR VPWR _0908_/S sky130_fd_sc_hd__clkbuf_2
X_1378_ _1651_/Q _1751_/Q _1382_/S VGND VGND VPWR VPWR _1379_/A sky130_fd_sc_hd__mux2_1
X_1447_ _1451_/A VGND VGND VPWR VPWR _1447_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1301_ _1301_/A VGND VGND VPWR VPWR _1686_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_1_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1232_ _1232_/A VGND VGND VPWR VPWR _1717_/D sky130_fd_sc_hd__clkbuf_1
X_1163_ _1162_/X _1746_/Q _1169_/S VGND VGND VPWR VPWR _1164_/A sky130_fd_sc_hd__mux2_1
X_1094_ _1767_/Q input16/X _1100_/S VGND VGND VPWR VPWR _1094_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0947_ _1809_/Q input62/X _0960_/S VGND VGND VPWR VPWR _0947_/X sky130_fd_sc_hd__mux2_1
X_0878_ _0895_/A VGND VGND VPWR VPWR _0891_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1781_ _1790_/CLK _1781_/D _1567_/Y VGND VGND VPWR VPWR _1781_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1146_ _1145_/X _1751_/Q _1152_/S VGND VGND VPWR VPWR _1147_/A sky130_fd_sc_hd__mux2_1
X_1215_ _1215_/A VGND VGND VPWR VPWR _1724_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1077_ _1077_/A VGND VGND VPWR VPWR _1771_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_9 input50/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1000_ _1171_/A VGND VGND VPWR VPWR _1069_/A sky130_fd_sc_hd__buf_2
XFILLER_19_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1764_ _1768_/CLK _1764_/D _1546_/Y VGND VGND VPWR VPWR _1764_/Q sky130_fd_sc_hd__dfrtp_1
X_1833_ _1833_/CLK _1833_/D _1631_/Y VGND VGND VPWR VPWR _1833_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1695_ _1803_/CLK _1695_/D _1461_/Y VGND VGND VPWR VPWR _1695_/Q sky130_fd_sc_hd__dfrtp_2
X_1129_ _1128_/X _1756_/Q _1135_/S VGND VGND VPWR VPWR _1130_/A sky130_fd_sc_hd__mux2_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput102 read VGND VGND VPWR VPWR _1084_/A sky130_fd_sc_hd__buf_2
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1480_ _1482_/A VGND VGND VPWR VPWR _1480_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1747_ _1843_/CLK _1747_/D _1525_/Y VGND VGND VPWR VPWR _1747_/Q sky130_fd_sc_hd__dfrtp_1
X_1678_ _1778_/CLK _1678_/D _1439_/Y VGND VGND VPWR VPWR _1678_/Q sky130_fd_sc_hd__dfrtp_1
X_1816_ _1817_/CLK _1816_/D _1610_/Y VGND VGND VPWR VPWR _1816_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0980_ _0980_/A VGND VGND VPWR VPWR _0994_/S sky130_fd_sc_hd__buf_2
X_1532_ _1532_/A VGND VGND VPWR VPWR _1532_/Y sky130_fd_sc_hd__inv_2
XFILLER_8_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1601_ _1607_/A VGND VGND VPWR VPWR _1606_/A sky130_fd_sc_hd__buf_2
X_1394_ _1394_/A VGND VGND VPWR VPWR _1644_/D sky130_fd_sc_hd__clkbuf_1
X_1463_ _1464_/A VGND VGND VPWR VPWR _1463_/Y sky130_fd_sc_hd__inv_2
XFILLER_35_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0894_ _1824_/Q input78/X _0907_/S VGND VGND VPWR VPWR _0894_/X sky130_fd_sc_hd__mux2_1
X_0963_ _0980_/A VGND VGND VPWR VPWR _0977_/S sky130_fd_sc_hd__clkbuf_2
X_1515_ _1519_/A VGND VGND VPWR VPWR _1515_/Y sky130_fd_sc_hd__inv_2
Xoutput203 _1743_/Q VGND VGND VPWR VPWR r_load[99] sky130_fd_sc_hd__buf_2
XFILLER_55_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1377_ _1377_/A VGND VGND VPWR VPWR _1652_/D sky130_fd_sc_hd__clkbuf_1
X_1446_ _1452_/A VGND VGND VPWR VPWR _1451_/A sky130_fd_sc_hd__buf_2
XFILLER_23_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1162_ _1747_/Q input24/X _1168_/S VGND VGND VPWR VPWR _1162_/X sky130_fd_sc_hd__mux2_1
X_1300_ _1686_/Q _1786_/Q _1304_/S VGND VGND VPWR VPWR _1301_/A sky130_fd_sc_hd__mux2_1
X_1231_ _1717_/Q _1817_/Q _1237_/S VGND VGND VPWR VPWR _1232_/A sky130_fd_sc_hd__mux2_1
X_1093_ _1093_/A VGND VGND VPWR VPWR _1767_/D sky130_fd_sc_hd__clkbuf_1
X_0877_ _1829_/Q input84/X _0890_/S VGND VGND VPWR VPWR _0877_/X sky130_fd_sc_hd__mux2_1
X_0946_ _0980_/A VGND VGND VPWR VPWR _0960_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_20_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1429_ _1433_/A VGND VGND VPWR VPWR _1429_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1780_ _1790_/CLK _1780_/D _1566_/Y VGND VGND VPWR VPWR _1780_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1145_ _1752_/Q input79/X _1151_/S VGND VGND VPWR VPWR _1145_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1214_ _1724_/Q _1824_/Q _1214_/S VGND VGND VPWR VPWR _1215_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1076_ _1075_/X _1771_/Q _1082_/S VGND VGND VPWR VPWR _1077_/A sky130_fd_sc_hd__mux2_1
X_0929_ _0980_/A VGND VGND VPWR VPWR _0943_/S sky130_fd_sc_hd__buf_2
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1832_ _1833_/CLK _1832_/D _1630_/Y VGND VGND VPWR VPWR _1832_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1763_ _1763_/CLK _1763_/D _1544_/Y VGND VGND VPWR VPWR _1763_/Q sky130_fd_sc_hd__dfrtp_1
X_1694_ _1798_/CLK _1694_/D _1460_/Y VGND VGND VPWR VPWR _1694_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_57_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1128_ _1757_/Q input5/X _1134_/S VGND VGND VPWR VPWR _1128_/X sky130_fd_sc_hd__mux2_1
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1059_ _1058_/X _1776_/Q _1065_/S VGND VGND VPWR VPWR _1060_/A sky130_fd_sc_hd__mux2_1
XFILLER_0_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput103 reset VGND VGND VPWR VPWR _1613_/A sky130_fd_sc_hd__buf_2
XFILLER_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1815_ _1817_/CLK _1815_/D _1609_/Y VGND VGND VPWR VPWR _1815_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_15_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1746_ _1758_/CLK _1746_/D _1524_/Y VGND VGND VPWR VPWR _1746_/Q sky130_fd_sc_hd__dfrtp_1
X_1677_ _1778_/CLK _1677_/D _1438_/Y VGND VGND VPWR VPWR _1677_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1531_ _1532_/A VGND VGND VPWR VPWR _1531_/Y sky130_fd_sc_hd__inv_2
X_1462_ _1464_/A VGND VGND VPWR VPWR _1462_/Y sky130_fd_sc_hd__inv_2
X_1600_ _1600_/A VGND VGND VPWR VPWR _1600_/Y sky130_fd_sc_hd__inv_2
X_1393_ _1644_/Q _1744_/Q _1393_/S VGND VGND VPWR VPWR _1394_/A sky130_fd_sc_hd__mux2_1
XFILLER_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1729_ _1798_/CLK _1729_/D _1503_/Y VGND VGND VPWR VPWR _1729_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_2_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0893_ _0893_/A VGND VGND VPWR VPWR _0907_/S sky130_fd_sc_hd__buf_2
X_0962_ _0962_/A VGND VGND VPWR VPWR _1804_/D sky130_fd_sc_hd__clkbuf_1
Xoutput204 _1653_/Q VGND VGND VPWR VPWR r_load[9] sky130_fd_sc_hd__buf_2
X_1514_ _1514_/A VGND VGND VPWR VPWR _1519_/A sky130_fd_sc_hd__buf_2
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1445_ _1445_/A VGND VGND VPWR VPWR _1445_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1376_ _1652_/Q _1752_/Q _1382_/S VGND VGND VPWR VPWR _1377_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1161_ _1161_/A VGND VGND VPWR VPWR _1747_/D sky130_fd_sc_hd__clkbuf_1
X_1092_ _1091_/X _1767_/Q _1101_/S VGND VGND VPWR VPWR _1093_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1230_ _1230_/A VGND VGND VPWR VPWR _1718_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0876_ _0893_/A VGND VGND VPWR VPWR _0890_/S sky130_fd_sc_hd__clkbuf_2
X_0945_ _0945_/A VGND VGND VPWR VPWR _1809_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1428_ _1452_/A VGND VGND VPWR VPWR _1433_/A sky130_fd_sc_hd__buf_2
XFILLER_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1359_ _1359_/A VGND VGND VPWR VPWR _1660_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_50_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1213_ _1213_/A VGND VGND VPWR VPWR _1725_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_52_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1144_ _1144_/A VGND VGND VPWR VPWR _1752_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1075_ _1772_/Q input21/X _1081_/S VGND VGND VPWR VPWR _1075_/X sky130_fd_sc_hd__mux2_1
X_0859_ _0893_/A VGND VGND VPWR VPWR _0873_/S sky130_fd_sc_hd__clkbuf_2
X_0928_ _0928_/A VGND VGND VPWR VPWR _1814_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1831_ _1838_/CLK _1831_/D _1629_/Y VGND VGND VPWR VPWR _1831_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_34_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1762_ _1763_/CLK _1762_/D _1543_/Y VGND VGND VPWR VPWR _1762_/Q sky130_fd_sc_hd__dfrtp_1
X_1693_ _1772_/CLK _1693_/D _1457_/Y VGND VGND VPWR VPWR _1693_/Q sky130_fd_sc_hd__dfrtp_4
X_1127_ _1127_/A VGND VGND VPWR VPWR _1757_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_40_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1058_ _1777_/Q input27/X _1064_/S VGND VGND VPWR VPWR _1058_/X sky130_fd_sc_hd__mux2_1
Xinput104 s_in VGND VGND VPWR VPWR _0824_/A0 sky130_fd_sc_hd__clkbuf_1
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1745_ _1822_/CLK _1745_/D _1523_/Y VGND VGND VPWR VPWR _1745_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1814_ _1817_/CLK _1814_/D _1608_/Y VGND VGND VPWR VPWR _1814_/Q sky130_fd_sc_hd__dfrtp_1
X_1676_ _1818_/CLK _1676_/D _1437_/Y VGND VGND VPWR VPWR _1676_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1530_ _1532_/A VGND VGND VPWR VPWR _1530_/Y sky130_fd_sc_hd__inv_2
X_1392_ _1392_/A VGND VGND VPWR VPWR _1645_/D sky130_fd_sc_hd__clkbuf_1
X_1461_ _1464_/A VGND VGND VPWR VPWR _1461_/Y sky130_fd_sc_hd__inv_2
X_1728_ _1837_/CLK _1728_/D _1501_/Y VGND VGND VPWR VPWR _1728_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ _1763_/CLK _1659_/D _1416_/Y VGND VGND VPWR VPWR _1659_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0961_ _0960_/X _1804_/Q _0961_/S VGND VGND VPWR VPWR _0962_/A sky130_fd_sc_hd__mux2_1
XFILLER_17_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0892_ _0892_/A VGND VGND VPWR VPWR _1824_/D sky130_fd_sc_hd__clkbuf_1
Xoutput205 _1744_/Q VGND VGND VPWR VPWR s_out sky130_fd_sc_hd__buf_2
X_1375_ _1375_/A VGND VGND VPWR VPWR _1653_/D sky130_fd_sc_hd__clkbuf_1
X_1513_ _1513_/A VGND VGND VPWR VPWR _1513_/Y sky130_fd_sc_hd__inv_2
X_1444_ _1445_/A VGND VGND VPWR VPWR _1444_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1160_ _1159_/X _1747_/Q _1169_/S VGND VGND VPWR VPWR _1161_/A sky130_fd_sc_hd__mux2_1
X_1091_ _1768_/Q input17/X _1100_/S VGND VGND VPWR VPWR _1091_/X sky130_fd_sc_hd__mux2_1
X_0944_ _0943_/X _1809_/Q _0944_/S VGND VGND VPWR VPWR _0945_/A sky130_fd_sc_hd__mux2_1
X_0875_ _0875_/A VGND VGND VPWR VPWR _1829_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_55_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1358_ _1660_/Q _1760_/Q _1360_/S VGND VGND VPWR VPWR _1359_/A sky130_fd_sc_hd__mux2_1
X_1427_ _1520_/A VGND VGND VPWR VPWR _1452_/A sky130_fd_sc_hd__buf_2
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1289_ _1691_/Q _1791_/Q _1293_/S VGND VGND VPWR VPWR _1290_/A sky130_fd_sc_hd__mux2_1
XFILLER_50_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1212_ _1725_/Q _1825_/Q _1214_/S VGND VGND VPWR VPWR _1213_/A sky130_fd_sc_hd__mux2_1
XFILLER_52_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1143_ _1142_/X _1752_/Q _1152_/S VGND VGND VPWR VPWR _1144_/A sky130_fd_sc_hd__mux2_1
X_1074_ _1074_/A VGND VGND VPWR VPWR _1772_/D sky130_fd_sc_hd__clkbuf_1
X_0927_ _0926_/X _1814_/Q _0927_/S VGND VGND VPWR VPWR _0928_/A sky130_fd_sc_hd__mux2_1
X_0858_ _0858_/A VGND VGND VPWR VPWR _1834_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1761_ _1763_/CLK _1761_/D _1542_/Y VGND VGND VPWR VPWR _1761_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1830_ _1838_/CLK _1830_/D _1628_/Y VGND VGND VPWR VPWR _1830_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1692_ _1793_/CLK _1692_/D _1456_/Y VGND VGND VPWR VPWR _1692_/Q sky130_fd_sc_hd__dfrtp_1
X_1126_ _1125_/X _1757_/Q _1135_/S VGND VGND VPWR VPWR _1127_/A sky130_fd_sc_hd__mux2_1
XFILLER_25_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1057_ _1057_/A VGND VGND VPWR VPWR _1777_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clkbuf_0_clk/X sky130_fd_sc_hd__clkbuf_16
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1744_ _1758_/CLK _1744_/D _1522_/Y VGND VGND VPWR VPWR _1744_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1813_ _1817_/CLK _1813_/D _1606_/Y VGND VGND VPWR VPWR _1813_/Q sky130_fd_sc_hd__dfrtp_1
X_1675_ _1778_/CLK _1675_/D _1436_/Y VGND VGND VPWR VPWR _1675_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1109_ _1108_/X _1762_/Q _1118_/S VGND VGND VPWR VPWR _1110_/A sky130_fd_sc_hd__mux2_1
XFILLER_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1391_ _1645_/Q _1745_/Q _1393_/S VGND VGND VPWR VPWR _1392_/A sky130_fd_sc_hd__mux2_1
X_1460_ _1464_/A VGND VGND VPWR VPWR _1460_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1658_ _1758_/CLK _1658_/D _1414_/Y VGND VGND VPWR VPWR _1658_/Q sky130_fd_sc_hd__dfrtp_1
X_1727_ _1837_/CLK _1727_/D _1500_/Y VGND VGND VPWR VPWR _1727_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1589_ _1607_/A VGND VGND VPWR VPWR _1594_/A sky130_fd_sc_hd__buf_2
XFILLER_41_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0960_ _1805_/Q input58/X _0960_/S VGND VGND VPWR VPWR _0960_/X sky130_fd_sc_hd__mux2_1
X_0891_ _0890_/X _1824_/Q _0891_/S VGND VGND VPWR VPWR _0892_/A sky130_fd_sc_hd__mux2_1
X_1512_ _1513_/A VGND VGND VPWR VPWR _1512_/Y sky130_fd_sc_hd__inv_2
X_1374_ _1653_/Q _1753_/Q _1382_/S VGND VGND VPWR VPWR _1375_/A sky130_fd_sc_hd__mux2_1
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1443_ _1445_/A VGND VGND VPWR VPWR _1443_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1090_ _1090_/A VGND VGND VPWR VPWR _1768_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0874_ _0873_/X _1829_/Q _0874_/S VGND VGND VPWR VPWR _0875_/A sky130_fd_sc_hd__mux2_1
X_0943_ _1810_/Q input63/X _0943_/S VGND VGND VPWR VPWR _0943_/X sky130_fd_sc_hd__mux2_1
X_1426_ _1426_/A VGND VGND VPWR VPWR _1426_/Y sky130_fd_sc_hd__inv_2
X_1357_ _1357_/A VGND VGND VPWR VPWR _1661_/D sky130_fd_sc_hd__clkbuf_1
X_1288_ _1288_/A VGND VGND VPWR VPWR _1692_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1142_ _1753_/Q input90/X _1151_/S VGND VGND VPWR VPWR _1142_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1211_ _1211_/A VGND VGND VPWR VPWR _1726_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1073_ _1072_/X _1772_/Q _1082_/S VGND VGND VPWR VPWR _1074_/A sky130_fd_sc_hd__mux2_1
X_0857_ _0856_/X _1834_/Q _0857_/S VGND VGND VPWR VPWR _0858_/A sky130_fd_sc_hd__mux2_1
X_0926_ _1815_/Q input69/X _0926_/S VGND VGND VPWR VPWR _0926_/X sky130_fd_sc_hd__mux2_1
X_1409_ _1421_/A VGND VGND VPWR VPWR _1414_/A sky130_fd_sc_hd__buf_2
XFILLER_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ _1763_/CLK _1760_/D _1541_/Y VGND VGND VPWR VPWR _1760_/Q sky130_fd_sc_hd__dfrtp_1
X_1691_ _1793_/CLK _1691_/D _1455_/Y VGND VGND VPWR VPWR _1691_/Q sky130_fd_sc_hd__dfrtp_1
X_1125_ _1758_/Q input6/X _1134_/S VGND VGND VPWR VPWR _1125_/X sky130_fd_sc_hd__mux2_1
XFILLER_25_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1056_ _1055_/X _1777_/Q _1065_/S VGND VGND VPWR VPWR _1057_/A sky130_fd_sc_hd__mux2_1
XFILLER_21_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0909_ _0909_/A VGND VGND VPWR VPWR _1819_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_31_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1743_ _1843_/CLK _1743_/D _1519_/Y VGND VGND VPWR VPWR _1743_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1674_ _1818_/CLK _1674_/D _1435_/Y VGND VGND VPWR VPWR _1674_/Q sky130_fd_sc_hd__dfrtp_1
X_1812_ _1817_/CLK _1812_/D _1605_/Y VGND VGND VPWR VPWR _1812_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1108_ _1763_/Q input11/X _1117_/S VGND VGND VPWR VPWR _1108_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1039_ _1038_/X _1782_/Q _1048_/S VGND VGND VPWR VPWR _1040_/A sky130_fd_sc_hd__mux2_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _1390_/A VGND VGND VPWR VPWR _1646_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_35_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1657_ _1758_/CLK _1657_/D _1413_/Y VGND VGND VPWR VPWR _1657_/Q sky130_fd_sc_hd__dfrtp_4
X_1588_ _1588_/A VGND VGND VPWR VPWR _1588_/Y sky130_fd_sc_hd__inv_2
X_1726_ _1837_/CLK _1726_/D _1499_/Y VGND VGND VPWR VPWR _1726_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_58_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0890_ _1825_/Q input80/X _0890_/S VGND VGND VPWR VPWR _0890_/X sky130_fd_sc_hd__mux2_1
XFILLER_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1511_ _1513_/A VGND VGND VPWR VPWR _1511_/Y sky130_fd_sc_hd__inv_2
X_1442_ _1445_/A VGND VGND VPWR VPWR _1442_/Y sky130_fd_sc_hd__inv_2
X_1373_ _1384_/A VGND VGND VPWR VPWR _1382_/S sky130_fd_sc_hd__buf_2
XFILLER_4_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1709_ _1818_/CLK _1709_/D _1478_/Y VGND VGND VPWR VPWR _1709_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0873_ _1830_/Q input85/X _0873_/S VGND VGND VPWR VPWR _0873_/X sky130_fd_sc_hd__mux2_1
X_0942_ _0942_/A VGND VGND VPWR VPWR _1810_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_13_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1425_ _1426_/A VGND VGND VPWR VPWR _1425_/Y sky130_fd_sc_hd__inv_2
X_1356_ _1661_/Q _1761_/Q _1360_/S VGND VGND VPWR VPWR _1357_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1287_ _1692_/Q _1792_/Q _1293_/S VGND VGND VPWR VPWR _1288_/A sky130_fd_sc_hd__mux2_1
XFILLER_50_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1141_ _1141_/A VGND VGND VPWR VPWR _1753_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_52_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1210_ _1726_/Q _1826_/Q _1214_/S VGND VGND VPWR VPWR _1211_/A sky130_fd_sc_hd__mux2_1
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1072_ _1773_/Q input22/X _1081_/S VGND VGND VPWR VPWR _1072_/X sky130_fd_sc_hd__mux2_1
XFILLER_33_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0856_ _1835_/Q input91/X _0856_/S VGND VGND VPWR VPWR _0856_/X sky130_fd_sc_hd__mux2_1
X_0925_ _0925_/A VGND VGND VPWR VPWR _1815_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1408_ _1408_/A VGND VGND VPWR VPWR _1408_/Y sky130_fd_sc_hd__inv_2
X_1339_ input1/X VGND VGND VPWR VPWR _1384_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_36_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1690_ _1793_/CLK _1690_/D _1454_/Y VGND VGND VPWR VPWR _1690_/Q sky130_fd_sc_hd__dfrtp_4
X_1124_ _1124_/A VGND VGND VPWR VPWR _1758_/D sky130_fd_sc_hd__clkbuf_1
X_1055_ _1778_/Q input28/X _1064_/S VGND VGND VPWR VPWR _1055_/X sky130_fd_sc_hd__mux2_1
XFILLER_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0839_ _1840_/Q input96/X _0839_/S VGND VGND VPWR VPWR _0839_/X sky130_fd_sc_hd__mux2_1
X_0908_ _0907_/X _1819_/Q _0908_/S VGND VGND VPWR VPWR _0909_/A sky130_fd_sc_hd__mux2_1
XFILLER_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1811_ _1817_/CLK _1811_/D _1604_/Y VGND VGND VPWR VPWR _1811_/Q sky130_fd_sc_hd__dfrtp_1
X_1742_ _1843_/CLK _1742_/D _1518_/Y VGND VGND VPWR VPWR _1742_/Q sky130_fd_sc_hd__dfrtp_1
X_1673_ _1778_/CLK _1673_/D _1433_/Y VGND VGND VPWR VPWR _1673_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1107_ _1107_/A VGND VGND VPWR VPWR _1763_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1038_ _1783_/Q input33/X _1047_/S VGND VGND VPWR VPWR _1038_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1725_ _1837_/CLK _1725_/D _1498_/Y VGND VGND VPWR VPWR _1725_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1656_ _1758_/CLK _1656_/D _1412_/Y VGND VGND VPWR VPWR _1656_/Q sky130_fd_sc_hd__dfrtp_4
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1587_ _1588_/A VGND VGND VPWR VPWR _1587_/Y sky130_fd_sc_hd__inv_2
XFILLER_7_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1510_ _1513_/A VGND VGND VPWR VPWR _1510_/Y sky130_fd_sc_hd__inv_2
XFILLER_4_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1441_ _1445_/A VGND VGND VPWR VPWR _1441_/Y sky130_fd_sc_hd__inv_2
X_1372_ _1372_/A VGND VGND VPWR VPWR _1654_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_16_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1708_ _1803_/CLK _1708_/D _1476_/Y VGND VGND VPWR VPWR _1708_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_58_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1639_ _1643_/A VGND VGND VPWR VPWR _1639_/Y sky130_fd_sc_hd__inv_2
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0941_ _0940_/X _1810_/Q _0944_/S VGND VGND VPWR VPWR _0942_/A sky130_fd_sc_hd__mux2_1
X_0872_ _0872_/A VGND VGND VPWR VPWR _1830_/D sky130_fd_sc_hd__clkbuf_1
X_1355_ _1355_/A VGND VGND VPWR VPWR _1662_/D sky130_fd_sc_hd__clkbuf_1
X_1424_ _1426_/A VGND VGND VPWR VPWR _1424_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1286_ _1286_/A VGND VGND VPWR VPWR _1693_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1140_ _1138_/X _1753_/Q _1152_/S VGND VGND VPWR VPWR _1141_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1071_ _1071_/A VGND VGND VPWR VPWR _1773_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_18_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0924_ _0923_/X _1815_/Q _0927_/S VGND VGND VPWR VPWR _0925_/A sky130_fd_sc_hd__mux2_1
X_0855_ _0855_/A VGND VGND VPWR VPWR _1835_/D sky130_fd_sc_hd__clkbuf_1
X_1407_ _1408_/A VGND VGND VPWR VPWR _1407_/Y sky130_fd_sc_hd__inv_2
XFILLER_28_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1338_ _1338_/A VGND VGND VPWR VPWR _1669_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1269_ _1269_/A VGND VGND VPWR VPWR _1700_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1123_ _1121_/X _1758_/Q _1135_/S VGND VGND VPWR VPWR _1124_/A sky130_fd_sc_hd__mux2_1
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1054_ _1054_/A VGND VGND VPWR VPWR _1778_/D sky130_fd_sc_hd__clkbuf_1
X_0907_ _1820_/Q input74/X _0907_/S VGND VGND VPWR VPWR _0907_/X sky130_fd_sc_hd__mux2_1
X_0838_ _0838_/A VGND VGND VPWR VPWR _1840_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1741_ _1843_/CLK _1741_/D _1517_/Y VGND VGND VPWR VPWR _1741_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1810_ _1817_/CLK _1810_/D _1603_/Y VGND VGND VPWR VPWR _1810_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_15_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1672_ _1772_/CLK _1672_/D _1432_/Y VGND VGND VPWR VPWR _1672_/Q sky130_fd_sc_hd__dfrtp_2
X_1106_ _1104_/X _1763_/Q _1118_/S VGND VGND VPWR VPWR _1107_/A sky130_fd_sc_hd__mux2_1
XFILLER_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1037_ _1037_/A VGND VGND VPWR VPWR _1783_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput90 r_read[8] VGND VGND VPWR VPWR input90/X sky130_fd_sc_hd__clkbuf_4
XFILLER_44_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1724_ _1837_/CLK _1724_/D _1497_/Y VGND VGND VPWR VPWR _1724_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1655_ _1758_/CLK _1655_/D _1411_/Y VGND VGND VPWR VPWR _1655_/Q sky130_fd_sc_hd__dfrtp_2
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1586_ _1588_/A VGND VGND VPWR VPWR _1586_/Y sky130_fd_sc_hd__inv_2
XFILLER_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1371_ _1654_/Q _1754_/Q _1371_/S VGND VGND VPWR VPWR _1372_/A sky130_fd_sc_hd__mux2_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1440_ _1452_/A VGND VGND VPWR VPWR _1445_/A sky130_fd_sc_hd__buf_2
XFILLER_23_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1638_ _1638_/A VGND VGND VPWR VPWR _1643_/A sky130_fd_sc_hd__buf_2
X_1707_ _1818_/CLK _1707_/D _1475_/Y VGND VGND VPWR VPWR _1707_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_58_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1569_ _1569_/A VGND VGND VPWR VPWR _1569_/Y sky130_fd_sc_hd__inv_2
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0940_ _1811_/Q input64/X _0943_/S VGND VGND VPWR VPWR _0940_/X sky130_fd_sc_hd__mux2_1
X_0871_ _0870_/X _1830_/Q _0874_/S VGND VGND VPWR VPWR _0872_/A sky130_fd_sc_hd__mux2_1
XFILLER_9_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1354_ _1662_/Q _1762_/Q _1360_/S VGND VGND VPWR VPWR _1355_/A sky130_fd_sc_hd__mux2_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1423_ _1426_/A VGND VGND VPWR VPWR _1423_/Y sky130_fd_sc_hd__inv_2
XFILLER_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1285_ _1693_/Q _1793_/Q _1293_/S VGND VGND VPWR VPWR _1286_/A sky130_fd_sc_hd__mux2_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1070_ _1068_/X _1773_/Q _1082_/S VGND VGND VPWR VPWR _1071_/A sky130_fd_sc_hd__mux2_1
X_0854_ _0853_/X _1835_/Q _0857_/S VGND VGND VPWR VPWR _0855_/A sky130_fd_sc_hd__mux2_1
X_0923_ _1816_/Q input70/X _0926_/S VGND VGND VPWR VPWR _0923_/X sky130_fd_sc_hd__mux2_1
X_1406_ _1408_/A VGND VGND VPWR VPWR _1406_/Y sky130_fd_sc_hd__inv_2
XFILLER_45_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1268_ _1700_/Q _1800_/Q _1270_/S VGND VGND VPWR VPWR _1269_/A sky130_fd_sc_hd__mux2_1
X_1337_ _1669_/Q _1769_/Q _1337_/S VGND VGND VPWR VPWR _1338_/A sky130_fd_sc_hd__mux2_1
XFILLER_36_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1199_ _1731_/Q _1831_/Q _1203_/S VGND VGND VPWR VPWR _1200_/A sky130_fd_sc_hd__mux2_1
XFILLER_24_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1122_ _1156_/A VGND VGND VPWR VPWR _1135_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1053_ _1051_/X _1778_/Q _1065_/S VGND VGND VPWR VPWR _1054_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0837_ _0836_/X _1840_/Q _0840_/S VGND VGND VPWR VPWR _0838_/A sky130_fd_sc_hd__mux2_1
X_0906_ _0906_/A VGND VGND VPWR VPWR _1820_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_56_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1740_ _1843_/CLK _1740_/D _1516_/Y VGND VGND VPWR VPWR _1740_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1671_ _1778_/CLK _1671_/D _1431_/Y VGND VGND VPWR VPWR _1671_/Q sky130_fd_sc_hd__dfrtp_1
X_1105_ _1156_/A VGND VGND VPWR VPWR _1118_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1036_ _1034_/X _1783_/Q _1048_/S VGND VGND VPWR VPWR _1037_/A sky130_fd_sc_hd__mux2_1
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput91 r_read[90] VGND VGND VPWR VPWR input91/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput80 r_read[80] VGND VGND VPWR VPWR input80/X sky130_fd_sc_hd__clkbuf_1
XFILLER_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1654_ _1758_/CLK _1654_/D _1410_/Y VGND VGND VPWR VPWR _1654_/Q sky130_fd_sc_hd__dfrtp_4
X_1723_ _1822_/CLK _1723_/D _1495_/Y VGND VGND VPWR VPWR _1723_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1585_ _1588_/A VGND VGND VPWR VPWR _1585_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1019_ _1017_/X _1788_/Q _1031_/S VGND VGND VPWR VPWR _1020_/A sky130_fd_sc_hd__mux2_1
XFILLER_43_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1370_ _1370_/A VGND VGND VPWR VPWR _1655_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_4_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1637_ _1637_/A VGND VGND VPWR VPWR _1637_/Y sky130_fd_sc_hd__inv_2
X_1706_ _1818_/CLK _1706_/D _1474_/Y VGND VGND VPWR VPWR _1706_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1499_ _1501_/A VGND VGND VPWR VPWR _1499_/Y sky130_fd_sc_hd__inv_2
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1568_ _1569_/A VGND VGND VPWR VPWR _1568_/Y sky130_fd_sc_hd__inv_2
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0870_ _1831_/Q input86/X _0873_/S VGND VGND VPWR VPWR _0870_/X sky130_fd_sc_hd__mux2_1
XFILLER_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1422_ _1426_/A VGND VGND VPWR VPWR _1422_/Y sky130_fd_sc_hd__inv_2
X_1353_ _1353_/A VGND VGND VPWR VPWR _1663_/D sky130_fd_sc_hd__clkbuf_1
X_1284_ _1328_/A VGND VGND VPWR VPWR _1293_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_51_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0999_ _1794_/Q input45/X _1013_/S VGND VGND VPWR VPWR _0999_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0853_ _1836_/Q input92/X _0856_/S VGND VGND VPWR VPWR _0853_/X sky130_fd_sc_hd__mux2_1
X_0922_ _0922_/A VGND VGND VPWR VPWR _1816_/D sky130_fd_sc_hd__clkbuf_1
X_1405_ _1408_/A VGND VGND VPWR VPWR _1405_/Y sky130_fd_sc_hd__inv_2
X_1198_ _1198_/A VGND VGND VPWR VPWR _1732_/D sky130_fd_sc_hd__clkbuf_1
Xinput1 load VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__buf_2
X_1267_ _1267_/A VGND VGND VPWR VPWR _1701_/D sky130_fd_sc_hd__clkbuf_1
X_1336_ _1336_/A VGND VGND VPWR VPWR _1670_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1121_ _1759_/Q input7/X _1134_/S VGND VGND VPWR VPWR _1121_/X sky130_fd_sc_hd__mux2_1
X_1052_ _1069_/A VGND VGND VPWR VPWR _1065_/S sky130_fd_sc_hd__clkbuf_2
X_0836_ _1841_/Q input97/X _0839_/S VGND VGND VPWR VPWR _0836_/X sky130_fd_sc_hd__mux2_1
X_0905_ _0904_/X _1820_/Q _0908_/S VGND VGND VPWR VPWR _0906_/A sky130_fd_sc_hd__mux2_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1319_ _1319_/A VGND VGND VPWR VPWR _1678_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput190 _1731_/Q VGND VGND VPWR VPWR r_load[87] sky130_fd_sc_hd__buf_2
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1670_ _1772_/CLK _1670_/D _1430_/Y VGND VGND VPWR VPWR _1670_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1104_ _1764_/Q input12/X _1117_/S VGND VGND VPWR VPWR _1104_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1035_ _1069_/A VGND VGND VPWR VPWR _1048_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput81 r_read[81] VGND VGND VPWR VPWR input81/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput92 r_read[91] VGND VGND VPWR VPWR input92/X sky130_fd_sc_hd__clkbuf_2
X_1799_ _1803_/CLK _1799_/D _1590_/Y VGND VGND VPWR VPWR _1799_/Q sky130_fd_sc_hd__dfrtp_1
Xinput70 r_read[71] VGND VGND VPWR VPWR input70/X sky130_fd_sc_hd__clkbuf_2
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1653_ _1768_/CLK _1653_/D _1408_/Y VGND VGND VPWR VPWR _1653_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1722_ _1822_/CLK _1722_/D _1494_/Y VGND VGND VPWR VPWR _1722_/Q sky130_fd_sc_hd__dfrtp_1
X_1584_ _1588_/A VGND VGND VPWR VPWR _1584_/Y sky130_fd_sc_hd__inv_2
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1018_ _1069_/A VGND VGND VPWR VPWR _1031_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_19_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1705_ _1818_/CLK _1705_/D _1473_/Y VGND VGND VPWR VPWR _1705_/Q sky130_fd_sc_hd__dfrtp_2
X_1636_ _1637_/A VGND VGND VPWR VPWR _1636_/Y sky130_fd_sc_hd__inv_2
X_1567_ _1569_/A VGND VGND VPWR VPWR _1567_/Y sky130_fd_sc_hd__inv_2
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1498_ _1501_/A VGND VGND VPWR VPWR _1498_/Y sky130_fd_sc_hd__inv_2
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1421_ _1421_/A VGND VGND VPWR VPWR _1426_/A sky130_fd_sc_hd__buf_2
X_1352_ _1663_/Q _1763_/Q _1360_/S VGND VGND VPWR VPWR _1353_/A sky130_fd_sc_hd__mux2_1
XFILLER_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1283_ input1/X VGND VGND VPWR VPWR _1328_/A sky130_fd_sc_hd__buf_2
X_0998_ _1067_/A VGND VGND VPWR VPWR _1013_/S sky130_fd_sc_hd__clkbuf_2
X_1619_ _1619_/A VGND VGND VPWR VPWR _1619_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0921_ _0920_/X _1816_/Q _0927_/S VGND VGND VPWR VPWR _0922_/A sky130_fd_sc_hd__mux2_1
X_0852_ _0852_/A VGND VGND VPWR VPWR _1836_/D sky130_fd_sc_hd__clkbuf_1
X_1404_ _1408_/A VGND VGND VPWR VPWR _1404_/Y sky130_fd_sc_hd__inv_2
X_1335_ _1670_/Q _1770_/Q _1337_/S VGND VGND VPWR VPWR _1336_/A sky130_fd_sc_hd__mux2_1
X_1197_ _1732_/Q _1832_/Q _1203_/S VGND VGND VPWR VPWR _1198_/A sky130_fd_sc_hd__mux2_1
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput2 r_read[0] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__buf_2
X_1266_ _1701_/Q _1801_/Q _1270_/S VGND VGND VPWR VPWR _1267_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1120_ _1154_/A VGND VGND VPWR VPWR _1134_/S sky130_fd_sc_hd__clkbuf_2
X_1051_ _1779_/Q input29/X _1064_/S VGND VGND VPWR VPWR _1051_/X sky130_fd_sc_hd__mux2_1
X_0904_ _1821_/Q input75/X _0907_/S VGND VGND VPWR VPWR _0904_/X sky130_fd_sc_hd__mux2_1
XFILLER_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0835_ _0835_/A VGND VGND VPWR VPWR _1841_/D sky130_fd_sc_hd__clkbuf_1
X_1318_ _1678_/Q _1778_/Q _1326_/S VGND VGND VPWR VPWR _1319_/A sky130_fd_sc_hd__mux2_1
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1249_ _1249_/A VGND VGND VPWR VPWR _1709_/D sky130_fd_sc_hd__clkbuf_1
Xoutput180 _1722_/Q VGND VGND VPWR VPWR r_load[78] sky130_fd_sc_hd__buf_2
Xoutput191 _1732_/Q VGND VGND VPWR VPWR r_load[88] sky130_fd_sc_hd__buf_2
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1103_ _1154_/A VGND VGND VPWR VPWR _1117_/S sky130_fd_sc_hd__clkbuf_2
X_1034_ _1784_/Q input34/X _1047_/S VGND VGND VPWR VPWR _1034_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput82 r_read[82] VGND VGND VPWR VPWR input82/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput71 r_read[72] VGND VGND VPWR VPWR input71/X sky130_fd_sc_hd__clkbuf_2
X_1798_ _1798_/CLK _1798_/D _1588_/Y VGND VGND VPWR VPWR _1798_/Q sky130_fd_sc_hd__dfrtp_1
Xinput60 r_read[62] VGND VGND VPWR VPWR input60/X sky130_fd_sc_hd__clkbuf_2
Xinput93 r_read[92] VGND VGND VPWR VPWR input93/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_44_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1721_ _1833_/CLK _1721_/D _1493_/Y VGND VGND VPWR VPWR _1721_/Q sky130_fd_sc_hd__dfrtp_2
X_1652_ _1768_/CLK _1652_/D _1407_/Y VGND VGND VPWR VPWR _1652_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1583_ _1607_/A VGND VGND VPWR VPWR _1588_/A sky130_fd_sc_hd__buf_2
XFILLER_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1017_ _1789_/Q input40/X _1030_/S VGND VGND VPWR VPWR _1017_/X sky130_fd_sc_hd__mux2_1
XFILLER_1_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1704_ _1803_/CLK _1704_/D _1472_/Y VGND VGND VPWR VPWR _1704_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1497_ _1501_/A VGND VGND VPWR VPWR _1497_/Y sky130_fd_sc_hd__inv_2
X_1635_ _1637_/A VGND VGND VPWR VPWR _1635_/Y sky130_fd_sc_hd__inv_2
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1566_ _1569_/A VGND VGND VPWR VPWR _1566_/Y sky130_fd_sc_hd__inv_2
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1420_ _1420_/A VGND VGND VPWR VPWR _1420_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1351_ _1384_/A VGND VGND VPWR VPWR _1360_/S sky130_fd_sc_hd__buf_2
XFILLER_48_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1282_ _1282_/A VGND VGND VPWR VPWR _1694_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1618_ _1619_/A VGND VGND VPWR VPWR _1618_/Y sky130_fd_sc_hd__inv_2
X_0997_ _1084_/A VGND VGND VPWR VPWR _1067_/A sky130_fd_sc_hd__clkbuf_2
X_1549_ _1550_/A VGND VGND VPWR VPWR _1549_/Y sky130_fd_sc_hd__inv_2
XFILLER_24_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0920_ _1817_/Q input71/X _0926_/S VGND VGND VPWR VPWR _0920_/X sky130_fd_sc_hd__mux2_1
X_0851_ _0850_/X _1836_/Q _0857_/S VGND VGND VPWR VPWR _0852_/A sky130_fd_sc_hd__mux2_1
X_1403_ _1421_/A VGND VGND VPWR VPWR _1408_/A sky130_fd_sc_hd__buf_2
X_1265_ _1265_/A VGND VGND VPWR VPWR _1702_/D sky130_fd_sc_hd__clkbuf_1
X_1334_ _1334_/A VGND VGND VPWR VPWR _1671_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput3 r_read[10] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__clkbuf_2
X_1196_ _1196_/A VGND VGND VPWR VPWR _1733_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1050_ _1067_/A VGND VGND VPWR VPWR _1064_/S sky130_fd_sc_hd__buf_2
X_0834_ _0833_/X _1841_/Q _0840_/S VGND VGND VPWR VPWR _0835_/A sky130_fd_sc_hd__mux2_1
X_0903_ _0903_/A VGND VGND VPWR VPWR _1821_/D sky130_fd_sc_hd__clkbuf_1
X_1317_ _1328_/A VGND VGND VPWR VPWR _1326_/S sky130_fd_sc_hd__clkbuf_2
X_1248_ _1709_/Q _1809_/Q _1248_/S VGND VGND VPWR VPWR _1249_/A sky130_fd_sc_hd__mux2_1
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1179_ _1740_/Q _1840_/Q _1181_/S VGND VGND VPWR VPWR _1180_/A sky130_fd_sc_hd__mux2_1
XFILLER_24_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput181 _1723_/Q VGND VGND VPWR VPWR r_load[79] sky130_fd_sc_hd__buf_2
Xoutput170 _1713_/Q VGND VGND VPWR VPWR r_load[69] sky130_fd_sc_hd__buf_2
Xoutput192 _1733_/Q VGND VGND VPWR VPWR r_load[89] sky130_fd_sc_hd__buf_2
XFILLER_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1102_ _1102_/A VGND VGND VPWR VPWR _1764_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1033_ _1067_/A VGND VGND VPWR VPWR _1047_/S sky130_fd_sc_hd__clkbuf_2
Xinput50 r_read[53] VGND VGND VPWR VPWR input50/X sky130_fd_sc_hd__buf_2
Xinput72 r_read[73] VGND VGND VPWR VPWR input72/X sky130_fd_sc_hd__clkbuf_2
X_1797_ _1798_/CLK _1797_/D _1587_/Y VGND VGND VPWR VPWR _1797_/Q sky130_fd_sc_hd__dfrtp_1
Xinput61 r_read[63] VGND VGND VPWR VPWR input61/X sky130_fd_sc_hd__clkbuf_1
Xinput83 r_read[83] VGND VGND VPWR VPWR input83/X sky130_fd_sc_hd__clkbuf_1
Xinput94 r_read[93] VGND VGND VPWR VPWR input94/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_16_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1651_ _1768_/CLK _1651_/D _1406_/Y VGND VGND VPWR VPWR _1651_/Q sky130_fd_sc_hd__dfrtp_2
X_1720_ _1822_/CLK _1720_/D _1492_/Y VGND VGND VPWR VPWR _1720_/Q sky130_fd_sc_hd__dfrtp_2
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1582_ _1613_/A VGND VGND VPWR VPWR _1607_/A sky130_fd_sc_hd__clkbuf_2
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1016_ _1067_/A VGND VGND VPWR VPWR _1030_/S sky130_fd_sc_hd__buf_2
XFILLER_57_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1634_ _1637_/A VGND VGND VPWR VPWR _1634_/Y sky130_fd_sc_hd__inv_2
X_1703_ _1803_/CLK _1703_/D _1470_/Y VGND VGND VPWR VPWR _1703_/Q sky130_fd_sc_hd__dfrtp_1
X_1496_ _1514_/A VGND VGND VPWR VPWR _1501_/A sky130_fd_sc_hd__buf_2
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1565_ _1569_/A VGND VGND VPWR VPWR _1565_/Y sky130_fd_sc_hd__inv_2
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1350_ _1350_/A VGND VGND VPWR VPWR _1664_/D sky130_fd_sc_hd__clkbuf_1
X_1281_ _1694_/Q _1794_/Q _1281_/S VGND VGND VPWR VPWR _1282_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0996_ _0996_/A VGND VGND VPWR VPWR _1794_/D sky130_fd_sc_hd__clkbuf_1
X_1617_ _1619_/A VGND VGND VPWR VPWR _1617_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1548_ _1550_/A VGND VGND VPWR VPWR _1548_/Y sky130_fd_sc_hd__inv_2
X_1479_ _1482_/A VGND VGND VPWR VPWR _1479_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0850_ _1837_/Q input93/X _0856_/S VGND VGND VPWR VPWR _0850_/X sky130_fd_sc_hd__mux2_1
X_1402_ _1402_/A VGND VGND VPWR VPWR _1402_/Y sky130_fd_sc_hd__inv_2
Xinput4 r_read[11] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__clkbuf_1
X_1264_ _1702_/Q _1802_/Q _1270_/S VGND VGND VPWR VPWR _1265_/A sky130_fd_sc_hd__mux2_1
X_1333_ _1671_/Q _1771_/Q _1337_/S VGND VGND VPWR VPWR _1334_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1195_ _1733_/Q _1833_/Q _1203_/S VGND VGND VPWR VPWR _1196_/A sky130_fd_sc_hd__mux2_1
X_0979_ _0979_/A VGND VGND VPWR VPWR _1799_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_27_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0833_ _1842_/Q input98/X _0839_/S VGND VGND VPWR VPWR _0833_/X sky130_fd_sc_hd__mux2_1
X_0902_ _0901_/X _1821_/Q _0908_/S VGND VGND VPWR VPWR _0903_/A sky130_fd_sc_hd__mux2_1
X_1178_ _1178_/A VGND VGND VPWR VPWR _1741_/D sky130_fd_sc_hd__clkbuf_1
X_1247_ _1247_/A VGND VGND VPWR VPWR _1710_/D sky130_fd_sc_hd__clkbuf_1
X_1316_ _1316_/A VGND VGND VPWR VPWR _1679_/D sky130_fd_sc_hd__clkbuf_1
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput171 _1650_/Q VGND VGND VPWR VPWR r_load[6] sky130_fd_sc_hd__buf_2
Xoutput160 _1649_/Q VGND VGND VPWR VPWR r_load[5] sky130_fd_sc_hd__buf_2
Xoutput193 _1652_/Q VGND VGND VPWR VPWR r_load[8] sky130_fd_sc_hd__buf_2
Xoutput182 _1651_/Q VGND VGND VPWR VPWR r_load[7] sky130_fd_sc_hd__buf_2
XFILLER_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1101_ _1100_/X _1764_/Q _1101_/S VGND VGND VPWR VPWR _1102_/A sky130_fd_sc_hd__mux2_1
X_1032_ _1032_/A VGND VGND VPWR VPWR _1784_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput40 r_read[44] VGND VGND VPWR VPWR input40/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput51 r_read[54] VGND VGND VPWR VPWR input51/X sky130_fd_sc_hd__clkbuf_1
Xinput73 r_read[74] VGND VGND VPWR VPWR input73/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput62 r_read[64] VGND VGND VPWR VPWR input62/X sky130_fd_sc_hd__clkbuf_2
Xinput84 r_read[84] VGND VGND VPWR VPWR input84/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput95 r_read[94] VGND VGND VPWR VPWR input95/X sky130_fd_sc_hd__clkbuf_2
X_1796_ _1798_/CLK _1796_/D _1586_/Y VGND VGND VPWR VPWR _1796_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1650_ _1768_/CLK _1650_/D _1405_/Y VGND VGND VPWR VPWR _1650_/Q sky130_fd_sc_hd__dfrtp_1
X_1581_ _1581_/A VGND VGND VPWR VPWR _1581_/Y sky130_fd_sc_hd__inv_2
XFILLER_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1015_ _1015_/A VGND VGND VPWR VPWR _1789_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1779_ _1790_/CLK _1779_/D _1565_/Y VGND VGND VPWR VPWR _1779_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1702_ _1822_/CLK _1702_/D _1469_/Y VGND VGND VPWR VPWR _1702_/Q sky130_fd_sc_hd__dfrtp_2
X_1633_ _1637_/A VGND VGND VPWR VPWR _1633_/Y sky130_fd_sc_hd__inv_2
X_1564_ _1576_/A VGND VGND VPWR VPWR _1569_/A sky130_fd_sc_hd__buf_2
XFILLER_58_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1495_ _1495_/A VGND VGND VPWR VPWR _1495_/Y sky130_fd_sc_hd__inv_2
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1280_ _1280_/A VGND VGND VPWR VPWR _1695_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0995_ _0994_/X _1794_/Q _0995_/S VGND VGND VPWR VPWR _0996_/A sky130_fd_sc_hd__mux2_1
X_1547_ _1550_/A VGND VGND VPWR VPWR _1547_/Y sky130_fd_sc_hd__inv_2
X_1616_ _1619_/A VGND VGND VPWR VPWR _1616_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1478_ _1482_/A VGND VGND VPWR VPWR _1478_/Y sky130_fd_sc_hd__inv_2
XFILLER_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1401_ _1402_/A VGND VGND VPWR VPWR _1401_/Y sky130_fd_sc_hd__inv_2
XFILLER_5_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput5 r_read[12] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1194_ _1216_/A VGND VGND VPWR VPWR _1203_/S sky130_fd_sc_hd__clkbuf_2
X_1263_ _1263_/A VGND VGND VPWR VPWR _1703_/D sky130_fd_sc_hd__clkbuf_1
X_1332_ _1332_/A VGND VGND VPWR VPWR _1672_/D sky130_fd_sc_hd__clkbuf_1
X_0978_ _0977_/X _1799_/Q _0978_/S VGND VGND VPWR VPWR _0979_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0832_ _0832_/A VGND VGND VPWR VPWR _1842_/D sky130_fd_sc_hd__clkbuf_1
X_0901_ _1822_/Q input76/X _0907_/S VGND VGND VPWR VPWR _0901_/X sky130_fd_sc_hd__mux2_1
X_1315_ _1679_/Q _1779_/Q _1315_/S VGND VGND VPWR VPWR _1316_/A sky130_fd_sc_hd__mux2_1
XFILLER_56_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1177_ _1741_/Q _1841_/Q _1181_/S VGND VGND VPWR VPWR _1178_/A sky130_fd_sc_hd__mux2_1
X_1246_ _1710_/Q _1810_/Q _1248_/S VGND VGND VPWR VPWR _1247_/A sky130_fd_sc_hd__mux2_1
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_10 input6/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput150 _1694_/Q VGND VGND VPWR VPWR r_load[50] sky130_fd_sc_hd__buf_2
Xoutput161 _1704_/Q VGND VGND VPWR VPWR r_load[60] sky130_fd_sc_hd__buf_2
XFILLER_47_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput183 _1724_/Q VGND VGND VPWR VPWR r_load[80] sky130_fd_sc_hd__buf_2
Xoutput172 _1714_/Q VGND VGND VPWR VPWR r_load[70] sky130_fd_sc_hd__buf_2
Xoutput194 _1734_/Q VGND VGND VPWR VPWR r_load[90] sky130_fd_sc_hd__buf_2
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_9_0_clk clkbuf_4_9_0_clk/A VGND VGND VPWR VPWR _1838_/CLK sky130_fd_sc_hd__clkbuf_2
X_1100_ _1765_/Q input14/X _1100_/S VGND VGND VPWR VPWR _1100_/X sky130_fd_sc_hd__mux2_1
X_1031_ _1030_/X _1784_/Q _1031_/S VGND VGND VPWR VPWR _1032_/A sky130_fd_sc_hd__mux2_1
XFILLER_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput74 r_read[75] VGND VGND VPWR VPWR input74/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput30 r_read[35] VGND VGND VPWR VPWR input30/X sky130_fd_sc_hd__buf_2
Xinput52 r_read[55] VGND VGND VPWR VPWR input52/X sky130_fd_sc_hd__buf_2
Xinput96 r_read[95] VGND VGND VPWR VPWR input96/X sky130_fd_sc_hd__clkbuf_1
Xinput63 r_read[65] VGND VGND VPWR VPWR input63/X sky130_fd_sc_hd__clkbuf_1
Xinput85 r_read[85] VGND VGND VPWR VPWR input85/X sky130_fd_sc_hd__clkbuf_2
Xinput41 r_read[45] VGND VGND VPWR VPWR input41/X sky130_fd_sc_hd__clkbuf_1
X_1795_ _1798_/CLK _1795_/D _1585_/Y VGND VGND VPWR VPWR _1795_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_52_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1229_ _1718_/Q _1818_/Q _1237_/S VGND VGND VPWR VPWR _1230_/A sky130_fd_sc_hd__mux2_1
XFILLER_32_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1580_ _1581_/A VGND VGND VPWR VPWR _1580_/Y sky130_fd_sc_hd__inv_2
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1014_ _1013_/X _1789_/Q _1014_/S VGND VGND VPWR VPWR _1015_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1778_ _1778_/CLK _1778_/D _1563_/Y VGND VGND VPWR VPWR _1778_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_27_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1701_ _1803_/CLK _1701_/D _1468_/Y VGND VGND VPWR VPWR _1701_/Q sky130_fd_sc_hd__dfrtp_1
X_1494_ _1495_/A VGND VGND VPWR VPWR _1494_/Y sky130_fd_sc_hd__inv_2
X_1632_ _1638_/A VGND VGND VPWR VPWR _1637_/A sky130_fd_sc_hd__buf_2
X_1563_ _1563_/A VGND VGND VPWR VPWR _1563_/Y sky130_fd_sc_hd__inv_2
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0994_ _1795_/Q input47/X _0994_/S VGND VGND VPWR VPWR _0994_/X sky130_fd_sc_hd__mux2_1
X_1546_ _1550_/A VGND VGND VPWR VPWR _1546_/Y sky130_fd_sc_hd__inv_2
X_1615_ _1619_/A VGND VGND VPWR VPWR _1615_/Y sky130_fd_sc_hd__inv_2
X_1477_ _1483_/A VGND VGND VPWR VPWR _1482_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_54_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1400_ _1402_/A VGND VGND VPWR VPWR _1400_/Y sky130_fd_sc_hd__inv_2
X_1331_ _1672_/Q _1772_/Q _1337_/S VGND VGND VPWR VPWR _1332_/A sky130_fd_sc_hd__mux2_1
Xinput6 r_read[13] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1193_ _1193_/A VGND VGND VPWR VPWR _1734_/D sky130_fd_sc_hd__clkbuf_1
X_1262_ _1703_/Q _1803_/Q _1270_/S VGND VGND VPWR VPWR _1263_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0977_ _1800_/Q input52/X _0977_/S VGND VGND VPWR VPWR _0977_/X sky130_fd_sc_hd__mux2_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1529_ _1532_/A VGND VGND VPWR VPWR _1529_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0900_ _0900_/A VGND VGND VPWR VPWR _1822_/D sky130_fd_sc_hd__clkbuf_1
X_0831_ _0830_/X _1842_/Q _0840_/S VGND VGND VPWR VPWR _0832_/A sky130_fd_sc_hd__mux2_1
X_1314_ _1314_/A VGND VGND VPWR VPWR _1680_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_49_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1176_ _1176_/A VGND VGND VPWR VPWR _1742_/D sky130_fd_sc_hd__clkbuf_1
X_1245_ _1245_/A VGND VGND VPWR VPWR _1711_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_11 input92/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput162 _1705_/Q VGND VGND VPWR VPWR r_load[61] sky130_fd_sc_hd__buf_2
Xoutput140 _1685_/Q VGND VGND VPWR VPWR r_load[41] sky130_fd_sc_hd__buf_2
Xoutput151 _1695_/Q VGND VGND VPWR VPWR r_load[51] sky130_fd_sc_hd__buf_2
Xoutput195 _1735_/Q VGND VGND VPWR VPWR r_load[91] sky130_fd_sc_hd__buf_2
Xoutput173 _1715_/Q VGND VGND VPWR VPWR r_load[71] sky130_fd_sc_hd__buf_2
Xoutput184 _1725_/Q VGND VGND VPWR VPWR r_load[81] sky130_fd_sc_hd__buf_2
XFILLER_55_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1030_ _1785_/Q input36/X _1030_/S VGND VGND VPWR VPWR _1030_/X sky130_fd_sc_hd__mux2_1
Xinput31 r_read[36] VGND VGND VPWR VPWR input31/X sky130_fd_sc_hd__clkbuf_1
Xinput20 r_read[26] VGND VGND VPWR VPWR input20/X sky130_fd_sc_hd__clkbuf_1
XFILLER_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput86 r_read[86] VGND VGND VPWR VPWR input86/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput75 r_read[76] VGND VGND VPWR VPWR input75/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1794_ _1798_/CLK _1794_/D _1584_/Y VGND VGND VPWR VPWR _1794_/Q sky130_fd_sc_hd__dfrtp_1
Xinput97 r_read[96] VGND VGND VPWR VPWR input97/X sky130_fd_sc_hd__clkbuf_2
Xinput53 r_read[56] VGND VGND VPWR VPWR input53/X sky130_fd_sc_hd__clkbuf_2
Xinput42 r_read[46] VGND VGND VPWR VPWR input42/X sky130_fd_sc_hd__clkbuf_2
Xinput64 r_read[66] VGND VGND VPWR VPWR input64/X sky130_fd_sc_hd__clkbuf_1
X_1228_ _1272_/A VGND VGND VPWR VPWR _1237_/S sky130_fd_sc_hd__clkbuf_2
X_1159_ _1748_/Q input35/X _1168_/S VGND VGND VPWR VPWR _1159_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1013_ _1790_/Q input41/X _1013_/S VGND VGND VPWR VPWR _1013_/X sky130_fd_sc_hd__mux2_1
X_1777_ _1778_/CLK _1777_/D _1562_/Y VGND VGND VPWR VPWR _1777_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_8_0_clk clkbuf_4_9_0_clk/A VGND VGND VPWR VPWR _1837_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1631_ _1631_/A VGND VGND VPWR VPWR _1631_/Y sky130_fd_sc_hd__inv_2
X_1700_ _1803_/CLK _1700_/D _1467_/Y VGND VGND VPWR VPWR _1700_/Q sky130_fd_sc_hd__dfrtp_1
X_1493_ _1495_/A VGND VGND VPWR VPWR _1493_/Y sky130_fd_sc_hd__inv_2
X_1562_ _1563_/A VGND VGND VPWR VPWR _1562_/Y sky130_fd_sc_hd__inv_2
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1829_ _1838_/CLK _1829_/D _1627_/Y VGND VGND VPWR VPWR _1829_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0993_ _0993_/A VGND VGND VPWR VPWR _1795_/D sky130_fd_sc_hd__clkbuf_1
X_1614_ _1638_/A VGND VGND VPWR VPWR _1619_/A sky130_fd_sc_hd__buf_2
X_1545_ _1545_/A VGND VGND VPWR VPWR _1550_/A sky130_fd_sc_hd__buf_2
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1476_ _1476_/A VGND VGND VPWR VPWR _1476_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1261_ _1272_/A VGND VGND VPWR VPWR _1270_/S sky130_fd_sc_hd__buf_2
X_1330_ _1330_/A VGND VGND VPWR VPWR _1673_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1192_ _1734_/Q _1834_/Q _1192_/S VGND VGND VPWR VPWR _1193_/A sky130_fd_sc_hd__mux2_1
XFILLER_24_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput7 r_read[14] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__buf_2
XFILLER_32_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0976_ _0976_/A VGND VGND VPWR VPWR _1800_/D sky130_fd_sc_hd__clkbuf_1
X_1528_ _1532_/A VGND VGND VPWR VPWR _1528_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1459_ _1483_/A VGND VGND VPWR VPWR _1464_/A sky130_fd_sc_hd__buf_2
XFILLER_51_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0830_ _1843_/Q input99/X _0839_/S VGND VGND VPWR VPWR _0830_/X sky130_fd_sc_hd__mux2_1
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1244_ _1711_/Q _1811_/Q _1248_/S VGND VGND VPWR VPWR _1245_/A sky130_fd_sc_hd__mux2_1
X_1313_ _1680_/Q _1780_/Q _1315_/S VGND VGND VPWR VPWR _1314_/A sky130_fd_sc_hd__mux2_1
X_1175_ _1742_/Q _1842_/Q _1181_/S VGND VGND VPWR VPWR _1176_/A sky130_fd_sc_hd__mux2_1
XFILLER_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_12 _1714_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0959_ _0959_/A VGND VGND VPWR VPWR _1805_/D sky130_fd_sc_hd__clkbuf_1
Xoutput141 _1686_/Q VGND VGND VPWR VPWR r_load[42] sky130_fd_sc_hd__buf_2
Xoutput130 _1676_/Q VGND VGND VPWR VPWR r_load[32] sky130_fd_sc_hd__buf_2
Xoutput163 _1706_/Q VGND VGND VPWR VPWR r_load[62] sky130_fd_sc_hd__buf_2
Xoutput174 _1716_/Q VGND VGND VPWR VPWR r_load[72] sky130_fd_sc_hd__buf_2
Xoutput185 _1726_/Q VGND VGND VPWR VPWR r_load[82] sky130_fd_sc_hd__buf_2
Xoutput196 _1736_/Q VGND VGND VPWR VPWR r_load[92] sky130_fd_sc_hd__buf_2
Xoutput152 _1696_/Q VGND VGND VPWR VPWR r_load[52] sky130_fd_sc_hd__buf_2
XFILLER_55_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput54 r_read[57] VGND VGND VPWR VPWR input54/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput32 r_read[37] VGND VGND VPWR VPWR input32/X sky130_fd_sc_hd__clkbuf_1
Xinput21 r_read[27] VGND VGND VPWR VPWR input21/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput10 r_read[17] VGND VGND VPWR VPWR input10/X sky130_fd_sc_hd__clkbuf_2
Xinput43 r_read[47] VGND VGND VPWR VPWR input43/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_14_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1793_ _1793_/CLK _1793_/D _1581_/Y VGND VGND VPWR VPWR _1793_/Q sky130_fd_sc_hd__dfrtp_1
Xinput98 r_read[97] VGND VGND VPWR VPWR input98/X sky130_fd_sc_hd__clkbuf_1
Xinput87 r_read[87] VGND VGND VPWR VPWR input87/X sky130_fd_sc_hd__clkbuf_1
Xinput65 r_read[67] VGND VGND VPWR VPWR input65/X sky130_fd_sc_hd__clkbuf_2
Xinput76 r_read[77] VGND VGND VPWR VPWR input76/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1158_ _1158_/A VGND VGND VPWR VPWR _1748_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_29_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1227_ input1/X VGND VGND VPWR VPWR _1272_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1089_ _1086_/X _1768_/Q _1101_/S VGND VGND VPWR VPWR _1090_/A sky130_fd_sc_hd__mux2_1
XFILLER_12_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1012_ _1012_/A VGND VGND VPWR VPWR _1790_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1776_ _1818_/CLK _1776_/D _1561_/Y VGND VGND VPWR VPWR _1776_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_27_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1630_ _1631_/A VGND VGND VPWR VPWR _1630_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1492_ _1495_/A VGND VGND VPWR VPWR _1492_/Y sky130_fd_sc_hd__inv_2
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1561_ _1563_/A VGND VGND VPWR VPWR _1561_/Y sky130_fd_sc_hd__inv_2
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1759_ _1763_/CLK _1759_/D _1540_/Y VGND VGND VPWR VPWR _1759_/Q sky130_fd_sc_hd__dfrtp_1
X_1828_ _1837_/CLK _1828_/D _1625_/Y VGND VGND VPWR VPWR _1828_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0992_ _0991_/X _1795_/Q _0995_/S VGND VGND VPWR VPWR _0993_/A sky130_fd_sc_hd__mux2_1
X_1544_ _1544_/A VGND VGND VPWR VPWR _1544_/Y sky130_fd_sc_hd__inv_2
X_1613_ _1613_/A VGND VGND VPWR VPWR _1638_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_39_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_7_0_clk clkbuf_4_7_0_clk/A VGND VGND VPWR VPWR _1803_/CLK sky130_fd_sc_hd__clkbuf_2
X_1475_ _1476_/A VGND VGND VPWR VPWR _1475_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 r_read[15] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__clkbuf_1
X_1191_ _1191_/A VGND VGND VPWR VPWR _1735_/D sky130_fd_sc_hd__clkbuf_1
X_1260_ _1260_/A VGND VGND VPWR VPWR _1704_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_44_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0975_ _0974_/X _1800_/Q _0978_/S VGND VGND VPWR VPWR _0976_/A sky130_fd_sc_hd__mux2_1
X_1527_ _1545_/A VGND VGND VPWR VPWR _1532_/A sky130_fd_sc_hd__buf_2
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1389_ _1646_/Q _1746_/Q _1393_/S VGND VGND VPWR VPWR _1390_/A sky130_fd_sc_hd__mux2_1
XFILLER_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1458_ _1520_/A VGND VGND VPWR VPWR _1483_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_19_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1174_ _1174_/A VGND VGND VPWR VPWR _1743_/D sky130_fd_sc_hd__clkbuf_1
X_1312_ _1312_/A VGND VGND VPWR VPWR _1681_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1243_ _1243_/A VGND VGND VPWR VPWR _1712_/D sky130_fd_sc_hd__clkbuf_1
XANTENNA_13 _1715_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0889_ _0889_/A VGND VGND VPWR VPWR _1825_/D sky130_fd_sc_hd__clkbuf_1
X_0958_ _0957_/X _1805_/Q _0961_/S VGND VGND VPWR VPWR _0959_/A sky130_fd_sc_hd__mux2_1
Xoutput142 _1687_/Q VGND VGND VPWR VPWR r_load[43] sky130_fd_sc_hd__buf_2
Xoutput153 _1697_/Q VGND VGND VPWR VPWR r_load[53] sky130_fd_sc_hd__buf_2
Xoutput175 _1717_/Q VGND VGND VPWR VPWR r_load[73] sky130_fd_sc_hd__buf_2
Xoutput197 _1737_/Q VGND VGND VPWR VPWR r_load[93] sky130_fd_sc_hd__buf_2
Xoutput120 _1667_/Q VGND VGND VPWR VPWR r_load[23] sky130_fd_sc_hd__buf_2
Xoutput164 _1707_/Q VGND VGND VPWR VPWR r_load[63] sky130_fd_sc_hd__buf_2
Xoutput186 _1727_/Q VGND VGND VPWR VPWR r_load[83] sky130_fd_sc_hd__buf_2
Xoutput131 _1677_/Q VGND VGND VPWR VPWR r_load[33] sky130_fd_sc_hd__buf_2
XFILLER_55_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput22 r_read[28] VGND VGND VPWR VPWR input22/X sky130_fd_sc_hd__buf_2
Xinput44 r_read[48] VGND VGND VPWR VPWR input44/X sky130_fd_sc_hd__buf_2
Xinput55 r_read[58] VGND VGND VPWR VPWR input55/X sky130_fd_sc_hd__clkbuf_2
Xinput11 r_read[18] VGND VGND VPWR VPWR input11/X sky130_fd_sc_hd__clkbuf_1
Xinput33 r_read[38] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput88 r_read[88] VGND VGND VPWR VPWR input88/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput77 r_read[78] VGND VGND VPWR VPWR input77/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput66 r_read[68] VGND VGND VPWR VPWR input66/X sky130_fd_sc_hd__clkbuf_2
X_1792_ _1793_/CLK _1792_/D _1580_/Y VGND VGND VPWR VPWR _1792_/Q sky130_fd_sc_hd__dfrtp_1
Xinput99 r_read[98] VGND VGND VPWR VPWR input99/X sky130_fd_sc_hd__clkbuf_1
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1157_ _1155_/X _1748_/Q _1169_/S VGND VGND VPWR VPWR _1158_/A sky130_fd_sc_hd__mux2_1
X_1226_ _1226_/A VGND VGND VPWR VPWR _1719_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1088_ _1156_/A VGND VGND VPWR VPWR _1101_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1011_ _1010_/X _1790_/Q _1014_/S VGND VGND VPWR VPWR _1012_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1775_ _1778_/CLK _1775_/D _1560_/Y VGND VGND VPWR VPWR _1775_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1209_ _1209_/A VGND VGND VPWR VPWR _1727_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_25_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1560_ _1563_/A VGND VGND VPWR VPWR _1560_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1491_ _1495_/A VGND VGND VPWR VPWR _1491_/Y sky130_fd_sc_hd__inv_2
XFILLER_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1827_ _1837_/CLK _1827_/D _1624_/Y VGND VGND VPWR VPWR _1827_/Q sky130_fd_sc_hd__dfrtp_1
X_1758_ _1758_/CLK _1758_/D _1538_/Y VGND VGND VPWR VPWR _1758_/Q sky130_fd_sc_hd__dfrtp_1
X_1689_ _1790_/CLK _1689_/D _1453_/Y VGND VGND VPWR VPWR _1689_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0991_ _1796_/Q input48/X _0994_/S VGND VGND VPWR VPWR _0991_/X sky130_fd_sc_hd__mux2_1
X_1543_ _1544_/A VGND VGND VPWR VPWR _1543_/Y sky130_fd_sc_hd__inv_2
XFILLER_5_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1612_ _1612_/A VGND VGND VPWR VPWR _1612_/Y sky130_fd_sc_hd__inv_2
X_1474_ _1476_/A VGND VGND VPWR VPWR _1474_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1190_ _1735_/Q _1835_/Q _1192_/S VGND VGND VPWR VPWR _1191_/A sky130_fd_sc_hd__mux2_1
Xinput9 r_read[16] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__buf_2
XFILLER_32_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0974_ _1801_/Q input53/X _0977_/S VGND VGND VPWR VPWR _0974_/X sky130_fd_sc_hd__mux2_1
X_1526_ _1526_/A VGND VGND VPWR VPWR _1526_/Y sky130_fd_sc_hd__inv_2
X_1457_ _1457_/A VGND VGND VPWR VPWR _1457_/Y sky130_fd_sc_hd__inv_2
X_1388_ _1388_/A VGND VGND VPWR VPWR _1647_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_42_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_6_0_clk clkbuf_4_7_0_clk/A VGND VGND VPWR VPWR _1798_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_25_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1311_ _1681_/Q _1781_/Q _1315_/S VGND VGND VPWR VPWR _1312_/A sky130_fd_sc_hd__mux2_1
X_1173_ _1743_/Q _1843_/Q _1181_/S VGND VGND VPWR VPWR _1174_/A sky130_fd_sc_hd__mux2_1
XFILLER_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1242_ _1712_/Q _1812_/Q _1248_/S VGND VGND VPWR VPWR _1243_/A sky130_fd_sc_hd__mux2_1
XFILLER_20_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput121 _1668_/Q VGND VGND VPWR VPWR r_load[24] sky130_fd_sc_hd__buf_2
Xoutput110 _1658_/Q VGND VGND VPWR VPWR r_load[14] sky130_fd_sc_hd__buf_2
X_0888_ _0887_/X _1825_/Q _0891_/S VGND VGND VPWR VPWR _0889_/A sky130_fd_sc_hd__mux2_1
Xoutput143 _1688_/Q VGND VGND VPWR VPWR r_load[44] sky130_fd_sc_hd__buf_2
Xoutput132 _1678_/Q VGND VGND VPWR VPWR r_load[34] sky130_fd_sc_hd__buf_2
X_0957_ _1806_/Q input59/X _0960_/S VGND VGND VPWR VPWR _0957_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput154 _1698_/Q VGND VGND VPWR VPWR r_load[54] sky130_fd_sc_hd__buf_2
Xoutput165 _1708_/Q VGND VGND VPWR VPWR r_load[64] sky130_fd_sc_hd__buf_2
Xoutput198 _1738_/Q VGND VGND VPWR VPWR r_load[94] sky130_fd_sc_hd__buf_2
X_1509_ _1513_/A VGND VGND VPWR VPWR _1509_/Y sky130_fd_sc_hd__inv_2
Xoutput176 _1718_/Q VGND VGND VPWR VPWR r_load[74] sky130_fd_sc_hd__buf_2
Xoutput187 _1728_/Q VGND VGND VPWR VPWR r_load[84] sky130_fd_sc_hd__buf_2
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput89 r_read[89] VGND VGND VPWR VPWR input89/X sky130_fd_sc_hd__clkbuf_2
Xinput45 r_read[49] VGND VGND VPWR VPWR input45/X sky130_fd_sc_hd__clkbuf_2
Xinput12 r_read[19] VGND VGND VPWR VPWR input12/X sky130_fd_sc_hd__clkbuf_1
Xinput34 r_read[39] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput67 r_read[69] VGND VGND VPWR VPWR input67/X sky130_fd_sc_hd__clkbuf_1
Xinput78 r_read[79] VGND VGND VPWR VPWR input78/X sky130_fd_sc_hd__clkbuf_2
Xinput56 r_read[59] VGND VGND VPWR VPWR input56/X sky130_fd_sc_hd__clkbuf_2
Xinput23 r_read[29] VGND VGND VPWR VPWR input23/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1791_ _1793_/CLK _1791_/D _1579_/Y VGND VGND VPWR VPWR _1791_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_52_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1156_ _1156_/A VGND VGND VPWR VPWR _1169_/S sky130_fd_sc_hd__clkbuf_2
X_1087_ _1171_/A VGND VGND VPWR VPWR _1156_/A sky130_fd_sc_hd__buf_2
X_1225_ _1719_/Q _1819_/Q _1225_/S VGND VGND VPWR VPWR _1226_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1010_ _1791_/Q input42/X _1013_/S VGND VGND VPWR VPWR _1010_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1843_ _1843_/CLK _1843_/D _1643_/Y VGND VGND VPWR VPWR _1843_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_8_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1774_ _1778_/CLK _1774_/D _1559_/Y VGND VGND VPWR VPWR _1774_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1208_ _1727_/Q _1827_/Q _1214_/S VGND VGND VPWR VPWR _1209_/A sky130_fd_sc_hd__mux2_1
X_1139_ _1156_/A VGND VGND VPWR VPWR _1152_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1490_ _1514_/A VGND VGND VPWR VPWR _1495_/A sky130_fd_sc_hd__buf_2
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1826_ _1837_/CLK _1826_/D _1623_/Y VGND VGND VPWR VPWR _1826_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1757_ _1763_/CLK _1757_/D _1537_/Y VGND VGND VPWR VPWR _1757_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1688_ _1793_/CLK _1688_/D _1451_/Y VGND VGND VPWR VPWR _1688_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_1_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _1612_/A VGND VGND VPWR VPWR _1611_/Y sky130_fd_sc_hd__inv_2
X_0990_ _0990_/A VGND VGND VPWR VPWR _1796_/D sky130_fd_sc_hd__clkbuf_1
X_1542_ _1544_/A VGND VGND VPWR VPWR _1542_/Y sky130_fd_sc_hd__inv_2
XFILLER_5_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1473_ _1476_/A VGND VGND VPWR VPWR _1473_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1809_ _1817_/CLK _1809_/D _1602_/Y VGND VGND VPWR VPWR _1809_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_26_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0973_ _0973_/A VGND VGND VPWR VPWR _1801_/D sky130_fd_sc_hd__clkbuf_1
X_1525_ _1526_/A VGND VGND VPWR VPWR _1525_/Y sky130_fd_sc_hd__inv_2
X_1387_ _1647_/Q _1747_/Q _1393_/S VGND VGND VPWR VPWR _1388_/A sky130_fd_sc_hd__mux2_1
X_1456_ _1457_/A VGND VGND VPWR VPWR _1456_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1310_ _1310_/A VGND VGND VPWR VPWR _1682_/D sky130_fd_sc_hd__clkbuf_1
X_1241_ _1241_/A VGND VGND VPWR VPWR _1713_/D sky130_fd_sc_hd__clkbuf_1
X_1172_ _1216_/A VGND VGND VPWR VPWR _1181_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_2_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0956_ _0956_/A VGND VGND VPWR VPWR _1806_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_20_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput122 _1669_/Q VGND VGND VPWR VPWR r_load[25] sky130_fd_sc_hd__buf_2
Xoutput177 _1719_/Q VGND VGND VPWR VPWR r_load[75] sky130_fd_sc_hd__buf_2
Xoutput111 _1659_/Q VGND VGND VPWR VPWR r_load[15] sky130_fd_sc_hd__buf_2
Xoutput166 _1709_/Q VGND VGND VPWR VPWR r_load[65] sky130_fd_sc_hd__buf_2
Xoutput133 _1679_/Q VGND VGND VPWR VPWR r_load[35] sky130_fd_sc_hd__buf_2
X_0887_ _1826_/Q input81/X _0890_/S VGND VGND VPWR VPWR _0887_/X sky130_fd_sc_hd__mux2_1
Xoutput155 _1699_/Q VGND VGND VPWR VPWR r_load[55] sky130_fd_sc_hd__buf_2
Xoutput144 _1689_/Q VGND VGND VPWR VPWR r_load[45] sky130_fd_sc_hd__buf_2
XFILLER_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1508_ _1514_/A VGND VGND VPWR VPWR _1513_/A sky130_fd_sc_hd__buf_2
X_1439_ _1439_/A VGND VGND VPWR VPWR _1439_/Y sky130_fd_sc_hd__inv_2
Xoutput188 _1729_/Q VGND VGND VPWR VPWR r_load[85] sky130_fd_sc_hd__buf_2
Xoutput199 _1739_/Q VGND VGND VPWR VPWR r_load[95] sky130_fd_sc_hd__buf_2
XFILLER_11_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xinput13 r_read[1] VGND VGND VPWR VPWR input13/X sky130_fd_sc_hd__clkbuf_2
X_1790_ _1790_/CLK _1790_/D _1578_/Y VGND VGND VPWR VPWR _1790_/Q sky130_fd_sc_hd__dfrtp_1
Xinput46 r_read[4] VGND VGND VPWR VPWR input46/X sky130_fd_sc_hd__clkbuf_1
Xinput35 r_read[3] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__clkbuf_1
Xinput24 r_read[2] VGND VGND VPWR VPWR input24/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput57 r_read[5] VGND VGND VPWR VPWR input57/X sky130_fd_sc_hd__buf_2
Xinput68 r_read[6] VGND VGND VPWR VPWR input68/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput79 r_read[7] VGND VGND VPWR VPWR input79/X sky130_fd_sc_hd__buf_2
X_1224_ _1224_/A VGND VGND VPWR VPWR _1720_/D sky130_fd_sc_hd__clkbuf_1
X_1155_ _1749_/Q input46/X _1168_/S VGND VGND VPWR VPWR _1155_/X sky130_fd_sc_hd__mux2_1
X_1086_ _1769_/Q input18/X _1100_/S VGND VGND VPWR VPWR _1086_/X sky130_fd_sc_hd__mux2_1
XFILLER_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0939_ _0939_/A VGND VGND VPWR VPWR _1811_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_20_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_5_0_clk clkbuf_4_5_0_clk/A VGND VGND VPWR VPWR _1817_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_3_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1842_ _1843_/CLK _1842_/D _1642_/Y VGND VGND VPWR VPWR _1842_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1773_ _1778_/CLK _1773_/D _1557_/Y VGND VGND VPWR VPWR _1773_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1207_ _1207_/A VGND VGND VPWR VPWR _1728_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_25_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1138_ _1754_/Q _1138_/A1 _1151_/S VGND VGND VPWR VPWR _1138_/X sky130_fd_sc_hd__mux2_1
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1069_ _1069_/A VGND VGND VPWR VPWR _1082_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_48_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1756_ _1763_/CLK _1756_/D _1536_/Y VGND VGND VPWR VPWR _1756_/Q sky130_fd_sc_hd__dfrtp_1
X_1825_ _1837_/CLK _1825_/D _1622_/Y VGND VGND VPWR VPWR _1825_/Q sky130_fd_sc_hd__dfrtp_1
X_1687_ _1793_/CLK _1687_/D _1450_/Y VGND VGND VPWR VPWR _1687_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1610_ _1612_/A VGND VGND VPWR VPWR _1610_/Y sky130_fd_sc_hd__inv_2
X_1541_ _1544_/A VGND VGND VPWR VPWR _1541_/Y sky130_fd_sc_hd__inv_2
XFILLER_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1472_ _1476_/A VGND VGND VPWR VPWR _1472_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1739_ _1822_/CLK _1739_/D _1515_/Y VGND VGND VPWR VPWR _1739_/Q sky130_fd_sc_hd__dfrtp_1
X_1808_ _1818_/CLK _1808_/D _1600_/Y VGND VGND VPWR VPWR _1808_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0972_ _0971_/X _1801_/Q _0978_/S VGND VGND VPWR VPWR _0973_/A sky130_fd_sc_hd__mux2_1
X_1524_ _1526_/A VGND VGND VPWR VPWR _1524_/Y sky130_fd_sc_hd__inv_2
X_1386_ _1386_/A VGND VGND VPWR VPWR _1648_/D sky130_fd_sc_hd__clkbuf_1
X_1455_ _1457_/A VGND VGND VPWR VPWR _1455_/Y sky130_fd_sc_hd__inv_2
XFILLER_58_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1171_ _1171_/A VGND VGND VPWR VPWR _1216_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1240_ _1713_/Q _1813_/Q _1248_/S VGND VGND VPWR VPWR _1241_/A sky130_fd_sc_hd__mux2_1
XFILLER_32_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0886_ _0886_/A VGND VGND VPWR VPWR _1826_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0955_ _0954_/X _1806_/Q _0961_/S VGND VGND VPWR VPWR _0956_/A sky130_fd_sc_hd__mux2_1
Xoutput123 _1670_/Q VGND VGND VPWR VPWR r_load[26] sky130_fd_sc_hd__buf_2
Xoutput145 _1690_/Q VGND VGND VPWR VPWR r_load[46] sky130_fd_sc_hd__buf_2
Xoutput112 _1660_/Q VGND VGND VPWR VPWR r_load[16] sky130_fd_sc_hd__buf_2
Xoutput189 _1730_/Q VGND VGND VPWR VPWR r_load[86] sky130_fd_sc_hd__buf_2
X_1507_ _1507_/A VGND VGND VPWR VPWR _1507_/Y sky130_fd_sc_hd__inv_2
Xoutput134 _1680_/Q VGND VGND VPWR VPWR r_load[36] sky130_fd_sc_hd__buf_2
Xoutput156 _1700_/Q VGND VGND VPWR VPWR r_load[56] sky130_fd_sc_hd__buf_2
Xoutput167 _1710_/Q VGND VGND VPWR VPWR r_load[66] sky130_fd_sc_hd__buf_2
Xoutput178 _1720_/Q VGND VGND VPWR VPWR r_load[76] sky130_fd_sc_hd__buf_2
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1369_ _1655_/Q _1755_/Q _1371_/S VGND VGND VPWR VPWR _1370_/A sky130_fd_sc_hd__mux2_1
X_1438_ _1439_/A VGND VGND VPWR VPWR _1438_/Y sky130_fd_sc_hd__inv_2
XFILLER_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xinput14 r_read[20] VGND VGND VPWR VPWR input14/X sky130_fd_sc_hd__clkbuf_1
XFILLER_52_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput36 r_read[40] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__clkbuf_1
Xinput25 r_read[30] VGND VGND VPWR VPWR input25/X sky130_fd_sc_hd__clkbuf_1
XFILLER_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput69 r_read[70] VGND VGND VPWR VPWR input69/X sky130_fd_sc_hd__clkbuf_1
Xinput58 r_read[60] VGND VGND VPWR VPWR input58/X sky130_fd_sc_hd__clkbuf_2
Xinput47 r_read[50] VGND VGND VPWR VPWR input47/X sky130_fd_sc_hd__clkbuf_2
X_1154_ _1154_/A VGND VGND VPWR VPWR _1168_/S sky130_fd_sc_hd__buf_2
X_1223_ _1720_/Q _1820_/Q _1225_/S VGND VGND VPWR VPWR _1224_/A sky130_fd_sc_hd__mux2_1
X_1085_ _1154_/A VGND VGND VPWR VPWR _1100_/S sky130_fd_sc_hd__clkbuf_2
X_0869_ _0869_/A VGND VGND VPWR VPWR _1831_/D sky130_fd_sc_hd__clkbuf_1
X_0938_ _0937_/X _1811_/Q _0944_/S VGND VGND VPWR VPWR _0939_/A sky130_fd_sc_hd__mux2_1
XFILLER_28_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1841_ _1843_/CLK _1841_/D _1641_/Y VGND VGND VPWR VPWR _1841_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_8_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1772_ _1772_/CLK _1772_/D _1556_/Y VGND VGND VPWR VPWR _1772_/Q sky130_fd_sc_hd__dfrtp_1
X_1137_ _1154_/A VGND VGND VPWR VPWR _1151_/S sky130_fd_sc_hd__clkbuf_2
X_1206_ _1728_/Q _1828_/Q _1214_/S VGND VGND VPWR VPWR _1207_/A sky130_fd_sc_hd__mux2_1
XFILLER_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1068_ _1774_/Q input23/X _1081_/S VGND VGND VPWR VPWR _1068_/X sky130_fd_sc_hd__mux2_1
XFILLER_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1755_ _1758_/CLK _1755_/D _1535_/Y VGND VGND VPWR VPWR _1755_/Q sky130_fd_sc_hd__dfrtp_1
X_1824_ _1837_/CLK _1824_/D _1621_/Y VGND VGND VPWR VPWR _1824_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1686_ _1793_/CLK _1686_/D _1449_/Y VGND VGND VPWR VPWR _1686_/Q sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_4_0_clk clkbuf_4_5_0_clk/A VGND VGND VPWR VPWR _1818_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_57_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1540_ _1544_/A VGND VGND VPWR VPWR _1540_/Y sky130_fd_sc_hd__inv_2
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1471_ _1483_/A VGND VGND VPWR VPWR _1476_/A sky130_fd_sc_hd__buf_2
XFILLER_54_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1807_ _1818_/CLK _1807_/D _1599_/Y VGND VGND VPWR VPWR _1807_/Q sky130_fd_sc_hd__dfrtp_1
X_1738_ _1838_/CLK _1738_/D _1513_/Y VGND VGND VPWR VPWR _1738_/Q sky130_fd_sc_hd__dfrtp_4
X_1669_ _1772_/CLK _1669_/D _1429_/Y VGND VGND VPWR VPWR _1669_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0971_ _1802_/Q input54/X _0977_/S VGND VGND VPWR VPWR _0971_/X sky130_fd_sc_hd__mux2_1
X_1523_ _1526_/A VGND VGND VPWR VPWR _1523_/Y sky130_fd_sc_hd__inv_2
X_1454_ _1457_/A VGND VGND VPWR VPWR _1454_/Y sky130_fd_sc_hd__inv_2
X_1385_ _1648_/Q _1748_/Q _1393_/S VGND VGND VPWR VPWR _1386_/A sky130_fd_sc_hd__mux2_1
XFILLER_50_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1170_ _1170_/A VGND VGND VPWR VPWR _1744_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_1_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0885_ _0884_/X _1826_/Q _0891_/S VGND VGND VPWR VPWR _0886_/A sky130_fd_sc_hd__mux2_1
XFILLER_32_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0954_ _1807_/Q input60/X _0960_/S VGND VGND VPWR VPWR _0954_/X sky130_fd_sc_hd__mux2_1
X_1506_ _1507_/A VGND VGND VPWR VPWR _1506_/Y sky130_fd_sc_hd__inv_2
Xoutput179 _1721_/Q VGND VGND VPWR VPWR r_load[77] sky130_fd_sc_hd__buf_2
Xoutput168 _1711_/Q VGND VGND VPWR VPWR r_load[67] sky130_fd_sc_hd__buf_2
Xoutput157 _1701_/Q VGND VGND VPWR VPWR r_load[57] sky130_fd_sc_hd__buf_2
Xoutput135 _1681_/Q VGND VGND VPWR VPWR r_load[37] sky130_fd_sc_hd__buf_2
X_1437_ _1439_/A VGND VGND VPWR VPWR _1437_/Y sky130_fd_sc_hd__inv_2
Xoutput124 _1671_/Q VGND VGND VPWR VPWR r_load[27] sky130_fd_sc_hd__buf_2
Xoutput113 _1661_/Q VGND VGND VPWR VPWR r_load[17] sky130_fd_sc_hd__buf_2
Xoutput146 _1691_/Q VGND VGND VPWR VPWR r_load[47] sky130_fd_sc_hd__buf_2
X_1368_ _1368_/A VGND VGND VPWR VPWR _1656_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1299_ _1299_/A VGND VGND VPWR VPWR _1687_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput15 r_read[21] VGND VGND VPWR VPWR input15/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_52_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput26 r_read[31] VGND VGND VPWR VPWR input26/X sky130_fd_sc_hd__clkbuf_2
Xinput59 r_read[61] VGND VGND VPWR VPWR input59/X sky130_fd_sc_hd__clkbuf_1
Xinput48 r_read[51] VGND VGND VPWR VPWR input48/X sky130_fd_sc_hd__clkbuf_1
Xinput37 r_read[41] VGND VGND VPWR VPWR input37/X sky130_fd_sc_hd__clkbuf_1
X_1153_ _1153_/A VGND VGND VPWR VPWR _1749_/D sky130_fd_sc_hd__clkbuf_1
X_1222_ _1222_/A VGND VGND VPWR VPWR _1721_/D sky130_fd_sc_hd__clkbuf_1
X_1084_ _1084_/A VGND VGND VPWR VPWR _1154_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0868_ _0867_/X _1831_/Q _0874_/S VGND VGND VPWR VPWR _0869_/A sky130_fd_sc_hd__mux2_1
XFILLER_9_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0937_ _1812_/Q input65/X _0943_/S VGND VGND VPWR VPWR _0937_/X sky130_fd_sc_hd__mux2_1
XFILLER_57_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1840_ _1843_/CLK _1840_/D _1640_/Y VGND VGND VPWR VPWR _1840_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1771_ _1778_/CLK _1771_/D _1555_/Y VGND VGND VPWR VPWR _1771_/Q sky130_fd_sc_hd__dfrtp_1
X_1136_ _1136_/A VGND VGND VPWR VPWR _1754_/D sky130_fd_sc_hd__clkbuf_1
X_1205_ _1216_/A VGND VGND VPWR VPWR _1214_/S sky130_fd_sc_hd__buf_2
XFILLER_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1067_ _1067_/A VGND VGND VPWR VPWR _1081_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1823_ _1833_/CLK _1823_/D _1619_/Y VGND VGND VPWR VPWR _1823_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1754_ _1758_/CLK _1754_/D _1534_/Y VGND VGND VPWR VPWR _1754_/Q sky130_fd_sc_hd__dfrtp_1
X_1685_ _1837_/CLK _1685_/D _1448_/Y VGND VGND VPWR VPWR _1685_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_57_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1119_ _1119_/A VGND VGND VPWR VPWR _1759_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1470_ _1470_/A VGND VGND VPWR VPWR _1470_/Y sky130_fd_sc_hd__inv_2
XFILLER_8_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1806_ _1818_/CLK _1806_/D _1598_/Y VGND VGND VPWR VPWR _1806_/Q sky130_fd_sc_hd__dfrtp_1
X_1668_ _1763_/CLK _1668_/D _1426_/Y VGND VGND VPWR VPWR _1668_/Q sky130_fd_sc_hd__dfrtp_4
X_1737_ _1838_/CLK _1737_/D _1512_/Y VGND VGND VPWR VPWR _1737_/Q sky130_fd_sc_hd__dfrtp_1
X_1599_ _1600_/A VGND VGND VPWR VPWR _1599_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_3_0_clk clkbuf_4_3_0_clk/A VGND VGND VPWR VPWR _1772_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_55_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0970_ _0970_/A VGND VGND VPWR VPWR _1802_/D sky130_fd_sc_hd__clkbuf_1
X_1522_ _1526_/A VGND VGND VPWR VPWR _1522_/Y sky130_fd_sc_hd__inv_2
XFILLER_4_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1453_ _1457_/A VGND VGND VPWR VPWR _1453_/Y sky130_fd_sc_hd__inv_2
X_1384_ _1384_/A VGND VGND VPWR VPWR _1393_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_35_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput125 _1672_/Q VGND VGND VPWR VPWR r_load[28] sky130_fd_sc_hd__buf_2
Xoutput114 _1662_/Q VGND VGND VPWR VPWR r_load[18] sky130_fd_sc_hd__buf_2
X_0884_ _1827_/Q input82/X _0890_/S VGND VGND VPWR VPWR _0884_/X sky130_fd_sc_hd__mux2_1
X_0953_ _0953_/A VGND VGND VPWR VPWR _1807_/D sky130_fd_sc_hd__clkbuf_1
Xoutput158 _1702_/Q VGND VGND VPWR VPWR r_load[58] sky130_fd_sc_hd__buf_2
X_1367_ _1656_/Q _1756_/Q _1371_/S VGND VGND VPWR VPWR _1368_/A sky130_fd_sc_hd__mux2_1
Xoutput169 _1712_/Q VGND VGND VPWR VPWR r_load[68] sky130_fd_sc_hd__buf_2
X_1505_ _1507_/A VGND VGND VPWR VPWR _1505_/Y sky130_fd_sc_hd__inv_2
Xoutput147 _1692_/Q VGND VGND VPWR VPWR r_load[48] sky130_fd_sc_hd__buf_2
Xoutput136 _1682_/Q VGND VGND VPWR VPWR r_load[38] sky130_fd_sc_hd__buf_2
X_1436_ _1439_/A VGND VGND VPWR VPWR _1436_/Y sky130_fd_sc_hd__inv_2
X_1298_ _1687_/Q _1787_/Q _1304_/S VGND VGND VPWR VPWR _1299_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput38 r_read[42] VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_2
Xinput27 r_read[32] VGND VGND VPWR VPWR input27/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput16 r_read[22] VGND VGND VPWR VPWR input16/X sky130_fd_sc_hd__clkbuf_2
Xinput49 r_read[52] VGND VGND VPWR VPWR input49/X sky130_fd_sc_hd__clkbuf_2
XFILLER_42_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1221_ _1721_/Q _1821_/Q _1225_/S VGND VGND VPWR VPWR _1222_/A sky130_fd_sc_hd__mux2_1
X_1152_ _1151_/X _1749_/Q _1152_/S VGND VGND VPWR VPWR _1153_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1083_ _1083_/A VGND VGND VPWR VPWR _1769_/D sky130_fd_sc_hd__clkbuf_1
X_0936_ _0936_/A VGND VGND VPWR VPWR _1812_/D sky130_fd_sc_hd__clkbuf_1
X_0867_ _1832_/Q input87/X _0873_/S VGND VGND VPWR VPWR _0867_/X sky130_fd_sc_hd__mux2_1
X_1419_ _1420_/A VGND VGND VPWR VPWR _1419_/Y sky130_fd_sc_hd__inv_2
XFILLER_43_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1770_ _1772_/CLK _1770_/D _1554_/Y VGND VGND VPWR VPWR _1770_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1204_ _1204_/A VGND VGND VPWR VPWR _1729_/D sky130_fd_sc_hd__clkbuf_1
X_1135_ _1134_/X _1754_/Q _1135_/S VGND VGND VPWR VPWR _1136_/A sky130_fd_sc_hd__mux2_1
X_1066_ _1066_/A VGND VGND VPWR VPWR _1774_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0919_ _0919_/A VGND VGND VPWR VPWR _1817_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1753_ _1768_/CLK _1753_/D _1532_/Y VGND VGND VPWR VPWR _1753_/Q sky130_fd_sc_hd__dfrtp_1
X_1822_ _1822_/CLK _1822_/D _1618_/Y VGND VGND VPWR VPWR _1822_/Q sky130_fd_sc_hd__dfrtp_1
X_1684_ _1793_/CLK _1684_/D _1447_/Y VGND VGND VPWR VPWR _1684_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1118_ _1117_/X _1759_/Q _1118_/S VGND VGND VPWR VPWR _1119_/A sky130_fd_sc_hd__mux2_1
X_1049_ _1049_/A VGND VGND VPWR VPWR _1779_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_13_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1736_ _1793_/CLK _1736_/D _1511_/Y VGND VGND VPWR VPWR _1736_/Q sky130_fd_sc_hd__dfrtp_2
X_1805_ _1818_/CLK _1805_/D _1597_/Y VGND VGND VPWR VPWR _1805_/Q sky130_fd_sc_hd__dfrtp_1
X_1667_ _1837_/CLK _1667_/D _1425_/Y VGND VGND VPWR VPWR _1667_/Q sky130_fd_sc_hd__dfrtp_1
X_1598_ _1600_/A VGND VGND VPWR VPWR _1598_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1383_ _1383_/A VGND VGND VPWR VPWR _1649_/D sky130_fd_sc_hd__clkbuf_1
X_1521_ _1545_/A VGND VGND VPWR VPWR _1526_/A sky130_fd_sc_hd__buf_2
XFILLER_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1452_ _1452_/A VGND VGND VPWR VPWR _1457_/A sky130_fd_sc_hd__buf_2
XFILLER_50_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1719_ _1833_/CLK _1719_/D _1491_/Y VGND VGND VPWR VPWR _1719_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_2_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0952_ _0951_/X _1807_/Q _0961_/S VGND VGND VPWR VPWR _0953_/A sky130_fd_sc_hd__mux2_1
XFILLER_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput137 _1683_/Q VGND VGND VPWR VPWR r_load[39] sky130_fd_sc_hd__buf_2
Xoutput115 _1663_/Q VGND VGND VPWR VPWR r_load[19] sky130_fd_sc_hd__buf_2
Xoutput148 _1693_/Q VGND VGND VPWR VPWR r_load[49] sky130_fd_sc_hd__buf_2
X_0883_ _0883_/A VGND VGND VPWR VPWR _1827_/D sky130_fd_sc_hd__clkbuf_1
X_1504_ _1507_/A VGND VGND VPWR VPWR _1504_/Y sky130_fd_sc_hd__inv_2
Xoutput159 _1703_/Q VGND VGND VPWR VPWR r_load[59] sky130_fd_sc_hd__buf_2
Xoutput126 _1673_/Q VGND VGND VPWR VPWR r_load[29] sky130_fd_sc_hd__buf_2
X_1366_ _1366_/A VGND VGND VPWR VPWR _1657_/D sky130_fd_sc_hd__clkbuf_1
X_1435_ _1439_/A VGND VGND VPWR VPWR _1435_/Y sky130_fd_sc_hd__inv_2
X_1297_ _1297_/A VGND VGND VPWR VPWR _1688_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_2_0_clk clkbuf_4_3_0_clk/A VGND VGND VPWR VPWR _1793_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_46_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput17 r_read[23] VGND VGND VPWR VPWR input17/X sky130_fd_sc_hd__clkbuf_1
Xinput39 r_read[43] VGND VGND VPWR VPWR input39/X sky130_fd_sc_hd__clkbuf_1
Xinput28 r_read[33] VGND VGND VPWR VPWR input28/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1151_ _1750_/Q input57/X _1151_/S VGND VGND VPWR VPWR _1151_/X sky130_fd_sc_hd__mux2_1
X_1220_ _1220_/A VGND VGND VPWR VPWR _1722_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_35_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1082_ _1081_/X _1769_/Q _1082_/S VGND VGND VPWR VPWR _1083_/A sky130_fd_sc_hd__mux2_1
X_0866_ _0866_/A VGND VGND VPWR VPWR _1832_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_9_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0935_ _0934_/X _1812_/Q _0944_/S VGND VGND VPWR VPWR _0936_/A sky130_fd_sc_hd__mux2_1
X_1349_ _1664_/Q _1764_/Q _1349_/S VGND VGND VPWR VPWR _1350_/A sky130_fd_sc_hd__mux2_1
X_1418_ _1420_/A VGND VGND VPWR VPWR _1418_/Y sky130_fd_sc_hd__inv_2
XFILLER_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1134_ _1755_/Q input3/X _1134_/S VGND VGND VPWR VPWR _1134_/X sky130_fd_sc_hd__mux2_1
X_1203_ _1729_/Q _1829_/Q _1203_/S VGND VGND VPWR VPWR _1204_/A sky130_fd_sc_hd__mux2_1
XFILLER_33_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1065_ _1064_/X _1774_/Q _1065_/S VGND VGND VPWR VPWR _1066_/A sky130_fd_sc_hd__mux2_1
X_0849_ _0849_/A VGND VGND VPWR VPWR _1837_/D sky130_fd_sc_hd__clkbuf_1
X_0918_ _0917_/X _1817_/Q _0927_/S VGND VGND VPWR VPWR _0919_/A sky130_fd_sc_hd__mux2_1
XFILLER_56_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1752_ _1768_/CLK _1752_/D _1531_/Y VGND VGND VPWR VPWR _1752_/Q sky130_fd_sc_hd__dfrtp_1
X_1821_ _1833_/CLK _1821_/D _1617_/Y VGND VGND VPWR VPWR _1821_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1683_ _1790_/CLK _1683_/D _1445_/Y VGND VGND VPWR VPWR _1683_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1117_ _1760_/Q input8/X _1117_/S VGND VGND VPWR VPWR _1117_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1048_ _1047_/X _1779_/Q _1048_/S VGND VGND VPWR VPWR _1049_/A sky130_fd_sc_hd__mux2_1
XFILLER_21_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1666_ _1763_/CLK _1666_/D _1424_/Y VGND VGND VPWR VPWR _1666_/Q sky130_fd_sc_hd__dfrtp_4
X_1735_ _1772_/CLK _1735_/D _1510_/Y VGND VGND VPWR VPWR _1735_/Q sky130_fd_sc_hd__dfrtp_4
X_1804_ _1818_/CLK _1804_/D _1596_/Y VGND VGND VPWR VPWR _1804_/Q sky130_fd_sc_hd__dfrtp_1
X_1597_ _1600_/A VGND VGND VPWR VPWR _1597_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1520_ _1520_/A VGND VGND VPWR VPWR _1545_/A sky130_fd_sc_hd__clkbuf_2
X_1382_ _1649_/Q _1749_/Q _1382_/S VGND VGND VPWR VPWR _1383_/A sky130_fd_sc_hd__mux2_1
X_1451_ _1451_/A VGND VGND VPWR VPWR _1451_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1649_ _1768_/CLK _1649_/D _1404_/Y VGND VGND VPWR VPWR _1649_/Q sky130_fd_sc_hd__dfrtp_1
X_1718_ _1817_/CLK _1718_/D _1488_/Y VGND VGND VPWR VPWR _1718_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_58_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0882_ _0881_/X _1827_/Q _0891_/S VGND VGND VPWR VPWR _0883_/A sky130_fd_sc_hd__mux2_1
XFILLER_32_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0951_ _1808_/Q input61/X _0960_/S VGND VGND VPWR VPWR _0951_/X sky130_fd_sc_hd__mux2_1
XFILLER_17_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput138 _1647_/Q VGND VGND VPWR VPWR r_load[3] sky130_fd_sc_hd__buf_2
Xoutput127 _1646_/Q VGND VGND VPWR VPWR r_load[2] sky130_fd_sc_hd__buf_2
X_1503_ _1507_/A VGND VGND VPWR VPWR _1503_/Y sky130_fd_sc_hd__inv_2
Xoutput116 _1645_/Q VGND VGND VPWR VPWR r_load[1] sky130_fd_sc_hd__buf_2
Xoutput105 _1644_/Q VGND VGND VPWR VPWR r_load[0] sky130_fd_sc_hd__buf_2
Xoutput149 _1648_/Q VGND VGND VPWR VPWR r_load[4] sky130_fd_sc_hd__buf_2
X_1365_ _1657_/Q _1757_/Q _1371_/S VGND VGND VPWR VPWR _1366_/A sky130_fd_sc_hd__mux2_1
X_1296_ _1688_/Q _1788_/Q _1304_/S VGND VGND VPWR VPWR _1297_/A sky130_fd_sc_hd__mux2_1
X_1434_ _1452_/A VGND VGND VPWR VPWR _1439_/A sky130_fd_sc_hd__buf_2
XFILLER_23_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 r_read[24] VGND VGND VPWR VPWR input18/X sky130_fd_sc_hd__buf_2
XFILLER_22_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput29 r_read[34] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__buf_2
X_1150_ _1150_/A VGND VGND VPWR VPWR _1750_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_28_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1081_ _1770_/Q input19/X _1081_/S VGND VGND VPWR VPWR _1081_/X sky130_fd_sc_hd__mux2_1
X_0865_ _0864_/X _1832_/Q _0874_/S VGND VGND VPWR VPWR _0866_/A sky130_fd_sc_hd__mux2_1
X_0934_ _1813_/Q input66/X _0943_/S VGND VGND VPWR VPWR _0934_/X sky130_fd_sc_hd__mux2_1
X_1417_ _1420_/A VGND VGND VPWR VPWR _1417_/Y sky130_fd_sc_hd__inv_2
X_1348_ _1348_/A VGND VGND VPWR VPWR _1665_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_28_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1279_ _1695_/Q _1795_/Q _1281_/S VGND VGND VPWR VPWR _1280_/A sky130_fd_sc_hd__mux2_1
XFILLER_36_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1133_ _1133_/A VGND VGND VPWR VPWR _1755_/D sky130_fd_sc_hd__clkbuf_1
X_1202_ _1202_/A VGND VGND VPWR VPWR _1730_/D sky130_fd_sc_hd__clkbuf_1
X_1064_ _1775_/Q input25/X _1064_/S VGND VGND VPWR VPWR _1064_/X sky130_fd_sc_hd__mux2_1
Xclkbuf_4_1_0_clk clkbuf_4_1_0_clk/A VGND VGND VPWR VPWR _1778_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0848_ _0847_/X _1837_/Q _0857_/S VGND VGND VPWR VPWR _0849_/A sky130_fd_sc_hd__mux2_1
X_0917_ _1818_/Q input72/X _0926_/S VGND VGND VPWR VPWR _0917_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1820_ _1822_/CLK _1820_/D _1616_/Y VGND VGND VPWR VPWR _1820_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_15_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1751_ _1768_/CLK _1751_/D _1530_/Y VGND VGND VPWR VPWR _1751_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1682_ _1790_/CLK _1682_/D _1444_/Y VGND VGND VPWR VPWR _1682_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1116_ _1116_/A VGND VGND VPWR VPWR _1760_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1047_ _1780_/Q input30/X _1047_/S VGND VGND VPWR VPWR _1047_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1803_ _1803_/CLK _1803_/D _1594_/Y VGND VGND VPWR VPWR _1803_/Q sky130_fd_sc_hd__dfrtp_1
X_1665_ _1768_/CLK _1665_/D _1423_/Y VGND VGND VPWR VPWR _1665_/Q sky130_fd_sc_hd__dfrtp_1
X_1734_ _1793_/CLK _1734_/D _1509_/Y VGND VGND VPWR VPWR _1734_/Q sky130_fd_sc_hd__dfrtp_1
X_1596_ _1600_/A VGND VGND VPWR VPWR _1596_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1450_ _1451_/A VGND VGND VPWR VPWR _1450_/Y sky130_fd_sc_hd__inv_2
XFILLER_4_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1381_ _1381_/A VGND VGND VPWR VPWR _1650_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1648_ _1843_/CLK _1648_/D _1402_/Y VGND VGND VPWR VPWR _1648_/Q sky130_fd_sc_hd__dfrtp_4
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1717_ _1817_/CLK _1717_/D _1487_/Y VGND VGND VPWR VPWR _1717_/Q sky130_fd_sc_hd__dfrtp_4
X_1579_ _1581_/A VGND VGND VPWR VPWR _1579_/Y sky130_fd_sc_hd__inv_2
XFILLER_58_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0881_ _1828_/Q input83/X _0890_/S VGND VGND VPWR VPWR _0881_/X sky130_fd_sc_hd__mux2_1
X_0950_ _0950_/A VGND VGND VPWR VPWR _1808_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput139 _1684_/Q VGND VGND VPWR VPWR r_load[40] sky130_fd_sc_hd__buf_2
X_1502_ _1514_/A VGND VGND VPWR VPWR _1507_/A sky130_fd_sc_hd__buf_2
Xoutput117 _1664_/Q VGND VGND VPWR VPWR r_load[20] sky130_fd_sc_hd__buf_2
Xoutput128 _1674_/Q VGND VGND VPWR VPWR r_load[30] sky130_fd_sc_hd__buf_2
Xoutput106 _1654_/Q VGND VGND VPWR VPWR r_load[10] sky130_fd_sc_hd__buf_2
X_1433_ _1433_/A VGND VGND VPWR VPWR _1433_/Y sky130_fd_sc_hd__inv_2
XFILLER_55_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1364_ _1364_/A VGND VGND VPWR VPWR _1658_/D sky130_fd_sc_hd__clkbuf_1
X_1295_ _1328_/A VGND VGND VPWR VPWR _1304_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 r_read[25] VGND VGND VPWR VPWR input19/X sky130_fd_sc_hd__clkbuf_2
XFILLER_6_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1080_ _1080_/A VGND VGND VPWR VPWR _1770_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_45_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0864_ _1833_/Q input88/X _0873_/S VGND VGND VPWR VPWR _0864_/X sky130_fd_sc_hd__mux2_1
X_0933_ _0933_/A VGND VGND VPWR VPWR _1813_/D sky130_fd_sc_hd__clkbuf_1
X_1416_ _1420_/A VGND VGND VPWR VPWR _1416_/Y sky130_fd_sc_hd__inv_2
X_1347_ _1665_/Q _1765_/Q _1349_/S VGND VGND VPWR VPWR _1348_/A sky130_fd_sc_hd__mux2_1
XFILLER_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1278_ _1278_/A VGND VGND VPWR VPWR _1696_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1201_ _1730_/Q _1830_/Q _1203_/S VGND VGND VPWR VPWR _1202_/A sky130_fd_sc_hd__mux2_1
X_1132_ _1131_/X _1755_/Q _1135_/S VGND VGND VPWR VPWR _1133_/A sky130_fd_sc_hd__mux2_1
X_1063_ _1063_/A VGND VGND VPWR VPWR _1775_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0916_ _0916_/A VGND VGND VPWR VPWR _1818_/D sky130_fd_sc_hd__clkbuf_1
X_0847_ _1838_/Q input94/X _0856_/S VGND VGND VPWR VPWR _0847_/X sky130_fd_sc_hd__mux2_1
XFILLER_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1750_ _1768_/CLK _1750_/D _1529_/Y VGND VGND VPWR VPWR _1750_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_30_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1681_ _1790_/CLK _1681_/D _1443_/Y VGND VGND VPWR VPWR _1681_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_38_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1115_ _1114_/X _1760_/Q _1118_/S VGND VGND VPWR VPWR _1116_/A sky130_fd_sc_hd__mux2_1
XFILLER_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1046_ _1046_/A VGND VGND VPWR VPWR _1780_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_0_0_clk clkbuf_4_1_0_clk/A VGND VGND VPWR VPWR _1790_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1802_ _1803_/CLK _1802_/D _1593_/Y VGND VGND VPWR VPWR _1802_/Q sky130_fd_sc_hd__dfrtp_1
X_1733_ _1772_/CLK _1733_/D _1507_/Y VGND VGND VPWR VPWR _1733_/Q sky130_fd_sc_hd__dfrtp_1
X_1664_ _1768_/CLK _1664_/D _1422_/Y VGND VGND VPWR VPWR _1664_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1595_ _1607_/A VGND VGND VPWR VPWR _1600_/A sky130_fd_sc_hd__buf_2
XFILLER_53_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1029_ _1029_/A VGND VGND VPWR VPWR _1785_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_39_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1380_ _1650_/Q _1750_/Q _1382_/S VGND VGND VPWR VPWR _1381_/A sky130_fd_sc_hd__mux2_1
XFILLER_4_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_7_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_3_7_0_clk/X sky130_fd_sc_hd__clkbuf_2
X_1716_ _1817_/CLK _1716_/D _1486_/Y VGND VGND VPWR VPWR _1716_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_58_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1647_ _1758_/CLK _1647_/D _1401_/Y VGND VGND VPWR VPWR _1647_/Q sky130_fd_sc_hd__dfrtp_2
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1578_ _1581_/A VGND VGND VPWR VPWR _1578_/Y sky130_fd_sc_hd__inv_2
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput107 _1655_/Q VGND VGND VPWR VPWR r_load[11] sky130_fd_sc_hd__buf_2
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0880_ _0880_/A VGND VGND VPWR VPWR _1828_/D sky130_fd_sc_hd__clkbuf_1
Xoutput118 _1665_/Q VGND VGND VPWR VPWR r_load[21] sky130_fd_sc_hd__buf_2
X_1363_ _1658_/Q _1758_/Q _1371_/S VGND VGND VPWR VPWR _1364_/A sky130_fd_sc_hd__mux2_1
X_1501_ _1501_/A VGND VGND VPWR VPWR _1501_/Y sky130_fd_sc_hd__inv_2
X_1432_ _1433_/A VGND VGND VPWR VPWR _1432_/Y sky130_fd_sc_hd__inv_2
Xoutput129 _1675_/Q VGND VGND VPWR VPWR r_load[31] sky130_fd_sc_hd__buf_2
XFILLER_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1294_ _1294_/A VGND VGND VPWR VPWR _1689_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_46_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0932_ _0930_/X _1813_/Q _0944_/S VGND VGND VPWR VPWR _0933_/A sky130_fd_sc_hd__mux2_1
X_0863_ _0863_/A VGND VGND VPWR VPWR _1833_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_9_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1415_ _1421_/A VGND VGND VPWR VPWR _1420_/A sky130_fd_sc_hd__buf_2
X_1346_ _1346_/A VGND VGND VPWR VPWR _1666_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_3_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1277_ _1696_/Q _1796_/Q _1281_/S VGND VGND VPWR VPWR _1278_/A sky130_fd_sc_hd__mux2_1
XFILLER_47_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1200_ _1200_/A VGND VGND VPWR VPWR _1731_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1131_ _1756_/Q input4/X _1134_/S VGND VGND VPWR VPWR _1131_/X sky130_fd_sc_hd__mux2_1
X_1062_ _1061_/X _1775_/Q _1065_/S VGND VGND VPWR VPWR _1063_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0915_ _0912_/X _1818_/Q _0927_/S VGND VGND VPWR VPWR _0916_/A sky130_fd_sc_hd__mux2_1
X_0846_ _0846_/A VGND VGND VPWR VPWR _1838_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1329_ _1673_/Q _1773_/Q _1337_/S VGND VGND VPWR VPWR _1330_/A sky130_fd_sc_hd__mux2_1
XFILLER_58_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1680_ _1790_/CLK _1680_/D _1442_/Y VGND VGND VPWR VPWR _1680_/Q sky130_fd_sc_hd__dfrtp_4
XFILLER_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1114_ _1761_/Q input9/X _1117_/S VGND VGND VPWR VPWR _1114_/X sky130_fd_sc_hd__mux2_1
XFILLER_2_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1045_ _1044_/X _1780_/Q _1048_/S VGND VGND VPWR VPWR _1046_/A sky130_fd_sc_hd__mux2_1
X_0829_ _0829_/A VGND VGND VPWR VPWR _1843_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1663_ _1763_/CLK _1663_/D _1420_/Y VGND VGND VPWR VPWR _1663_/Q sky130_fd_sc_hd__dfrtp_1
X_1732_ _1833_/CLK _1732_/D _1506_/Y VGND VGND VPWR VPWR _1732_/Q sky130_fd_sc_hd__dfrtp_1
X_1801_ _1803_/CLK _1801_/D _1592_/Y VGND VGND VPWR VPWR _1801_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1594_ _1594_/A VGND VGND VPWR VPWR _1594_/Y sky130_fd_sc_hd__inv_2
X_1028_ _1027_/X _1785_/Q _1031_/S VGND VGND VPWR VPWR _1029_/A sky130_fd_sc_hd__mux2_1
XFILLER_39_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1646_ _1758_/CLK _1646_/D _1400_/Y VGND VGND VPWR VPWR _1646_/Q sky130_fd_sc_hd__dfrtp_1
X_1715_ _1817_/CLK _1715_/D _1485_/Y VGND VGND VPWR VPWR _1715_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_6_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1577_ _1581_/A VGND VGND VPWR VPWR _1577_/Y sky130_fd_sc_hd__inv_2
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1500_ _1501_/A VGND VGND VPWR VPWR _1500_/Y sky130_fd_sc_hd__inv_2
Xoutput108 _1656_/Q VGND VGND VPWR VPWR r_load[12] sky130_fd_sc_hd__buf_2
Xoutput119 _1666_/Q VGND VGND VPWR VPWR r_load[22] sky130_fd_sc_hd__buf_2
X_1362_ _1384_/A VGND VGND VPWR VPWR _1371_/S sky130_fd_sc_hd__clkbuf_2
X_1293_ _1689_/Q _1789_/Q _1293_/S VGND VGND VPWR VPWR _1294_/A sky130_fd_sc_hd__mux2_1
X_1431_ _1433_/A VGND VGND VPWR VPWR _1431_/Y sky130_fd_sc_hd__inv_2
XFILLER_23_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1629_ _1631_/A VGND VGND VPWR VPWR _1629_/Y sky130_fd_sc_hd__inv_2
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_6_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_3_6_0_clk/X sky130_fd_sc_hd__clkbuf_2
X_0862_ _0860_/X _1833_/Q _0874_/S VGND VGND VPWR VPWR _0863_/A sky130_fd_sc_hd__mux2_1
X_0931_ _0982_/A VGND VGND VPWR VPWR _0944_/S sky130_fd_sc_hd__buf_2
X_1414_ _1414_/A VGND VGND VPWR VPWR _1414_/Y sky130_fd_sc_hd__inv_2
X_1345_ _1666_/Q _1766_/Q _1349_/S VGND VGND VPWR VPWR _1346_/A sky130_fd_sc_hd__mux2_1
X_1276_ _1276_/A VGND VGND VPWR VPWR _1697_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1130_ _1130_/A VGND VGND VPWR VPWR _1756_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_26_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1061_ _1776_/Q input26/X _1064_/S VGND VGND VPWR VPWR _1061_/X sky130_fd_sc_hd__mux2_1
XFILLER_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0845_ _0843_/X _1838_/Q _0857_/S VGND VGND VPWR VPWR _0846_/A sky130_fd_sc_hd__mux2_1
X_0914_ _0982_/A VGND VGND VPWR VPWR _0927_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1259_ _1704_/Q _1804_/Q _1259_/S VGND VGND VPWR VPWR _1260_/A sky130_fd_sc_hd__mux2_1
X_1328_ _1328_/A VGND VGND VPWR VPWR _1337_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1113_ _1113_/A VGND VGND VPWR VPWR _1761_/D sky130_fd_sc_hd__clkbuf_1
X_1044_ _1781_/Q input31/X _1047_/S VGND VGND VPWR VPWR _1044_/X sky130_fd_sc_hd__mux2_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0828_ _0824_/X _1843_/Q _0840_/S VGND VGND VPWR VPWR _0829_/A sky130_fd_sc_hd__mux2_1
XFILLER_29_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1800_ _1803_/CLK _1800_/D _1591_/Y VGND VGND VPWR VPWR _1800_/Q sky130_fd_sc_hd__dfrtp_1
X_1662_ _1768_/CLK _1662_/D _1419_/Y VGND VGND VPWR VPWR _1662_/Q sky130_fd_sc_hd__dfrtp_1
X_1731_ _1833_/CLK _1731_/D _1505_/Y VGND VGND VPWR VPWR _1731_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1593_ _1594_/A VGND VGND VPWR VPWR _1593_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1027_ _1786_/Q input37/X _1030_/S VGND VGND VPWR VPWR _1027_/X sky130_fd_sc_hd__mux2_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1645_ _1843_/CLK _1645_/D _1399_/Y VGND VGND VPWR VPWR _1645_/Q sky130_fd_sc_hd__dfrtp_4
X_1714_ _1817_/CLK _1714_/D _1484_/Y VGND VGND VPWR VPWR _1714_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_6_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1576_ _1576_/A VGND VGND VPWR VPWR _1581_/A sky130_fd_sc_hd__buf_2
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput109 _1657_/Q VGND VGND VPWR VPWR r_load[13] sky130_fd_sc_hd__buf_2
X_1430_ _1433_/A VGND VGND VPWR VPWR _1430_/Y sky130_fd_sc_hd__inv_2
X_1361_ _1361_/A VGND VGND VPWR VPWR _1659_/D sky130_fd_sc_hd__clkbuf_1
X_1292_ _1292_/A VGND VGND VPWR VPWR _1690_/D sky130_fd_sc_hd__clkbuf_1
X_1628_ _1631_/A VGND VGND VPWR VPWR _1628_/Y sky130_fd_sc_hd__inv_2
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1559_ _1563_/A VGND VGND VPWR VPWR _1559_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0861_ _0895_/A VGND VGND VPWR VPWR _0874_/S sky130_fd_sc_hd__clkbuf_2
X_0930_ _1814_/Q input67/X _0943_/S VGND VGND VPWR VPWR _0930_/X sky130_fd_sc_hd__mux2_1
XFILLER_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1413_ _1414_/A VGND VGND VPWR VPWR _1413_/Y sky130_fd_sc_hd__inv_2
X_1344_ _1344_/A VGND VGND VPWR VPWR _1667_/D sky130_fd_sc_hd__clkbuf_1
X_1275_ _1697_/Q _1797_/Q _1281_/S VGND VGND VPWR VPWR _1276_/A sky130_fd_sc_hd__mux2_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1060_ _1060_/A VGND VGND VPWR VPWR _1776_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0844_ _0895_/A VGND VGND VPWR VPWR _0857_/S sky130_fd_sc_hd__clkbuf_2
X_0913_ _1171_/A VGND VGND VPWR VPWR _0982_/A sky130_fd_sc_hd__clkbuf_2
X_1189_ _1189_/A VGND VGND VPWR VPWR _1736_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1327_ _1327_/A VGND VGND VPWR VPWR _1674_/D sky130_fd_sc_hd__clkbuf_1
X_1258_ _1258_/A VGND VGND VPWR VPWR _1705_/D sky130_fd_sc_hd__clkbuf_1
Xclkbuf_3_5_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_3_5_0_clk/X sky130_fd_sc_hd__clkbuf_2
XFILLER_58_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1112_ _1111_/X _1761_/Q _1118_/S VGND VGND VPWR VPWR _1113_/A sky130_fd_sc_hd__mux2_1
X_1043_ _1043_/A VGND VGND VPWR VPWR _1781_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0827_ _0895_/A VGND VGND VPWR VPWR _0840_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1661_ _1763_/CLK _1661_/D _1418_/Y VGND VGND VPWR VPWR _1661_/Q sky130_fd_sc_hd__dfrtp_4
X_1592_ _1594_/A VGND VGND VPWR VPWR _1592_/Y sky130_fd_sc_hd__inv_2
X_1730_ _1838_/CLK _1730_/D _1504_/Y VGND VGND VPWR VPWR _1730_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1026_ _1026_/A VGND VGND VPWR VPWR _1786_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_39_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1713_ _1817_/CLK _1713_/D _1482_/Y VGND VGND VPWR VPWR _1713_/Q sky130_fd_sc_hd__dfrtp_1
X_1644_ _1758_/CLK _1644_/D _1398_/Y VGND VGND VPWR VPWR _1644_/Q sky130_fd_sc_hd__dfrtp_4
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_0 _1644_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1575_ _1575_/A VGND VGND VPWR VPWR _1575_/Y sky130_fd_sc_hd__inv_2
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1009_ _1009_/A VGND VGND VPWR VPWR _1791_/D sky130_fd_sc_hd__clkbuf_1
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1360_ _1659_/Q _1759_/Q _1360_/S VGND VGND VPWR VPWR _1361_/A sky130_fd_sc_hd__mux2_1
XFILLER_48_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1291_ _1690_/Q _1790_/Q _1293_/S VGND VGND VPWR VPWR _1292_/A sky130_fd_sc_hd__mux2_1
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1489_ _1520_/A VGND VGND VPWR VPWR _1514_/A sky130_fd_sc_hd__clkbuf_2
X_1627_ _1631_/A VGND VGND VPWR VPWR _1627_/Y sky130_fd_sc_hd__inv_2
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1558_ _1576_/A VGND VGND VPWR VPWR _1563_/A sky130_fd_sc_hd__buf_2
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0860_ _1834_/Q input89/X _0873_/S VGND VGND VPWR VPWR _0860_/X sky130_fd_sc_hd__mux2_1
XFILLER_13_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1412_ _1414_/A VGND VGND VPWR VPWR _1412_/Y sky130_fd_sc_hd__inv_2
X_1343_ _1667_/Q _1767_/Q _1349_/S VGND VGND VPWR VPWR _1344_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1274_ _1274_/A VGND VGND VPWR VPWR _1698_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0989_ _0988_/X _1796_/Q _0995_/S VGND VGND VPWR VPWR _0990_/A sky130_fd_sc_hd__mux2_1
XFILLER_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0912_ _1819_/Q input73/X _0926_/S VGND VGND VPWR VPWR _0912_/X sky130_fd_sc_hd__mux2_1
X_0843_ _1839_/Q input95/X _0856_/S VGND VGND VPWR VPWR _0843_/X sky130_fd_sc_hd__mux2_1
XFILLER_56_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1326_ _1674_/Q _1774_/Q _1326_/S VGND VGND VPWR VPWR _1327_/A sky130_fd_sc_hd__mux2_1
X_1188_ _1736_/Q _1836_/Q _1192_/S VGND VGND VPWR VPWR _1189_/A sky130_fd_sc_hd__mux2_1
X_1257_ _1705_/Q _1805_/Q _1259_/S VGND VGND VPWR VPWR _1258_/A sky130_fd_sc_hd__mux2_1
XFILLER_33_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1111_ _1762_/Q input10/X _1117_/S VGND VGND VPWR VPWR _1111_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1042_ _1041_/X _1781_/Q _1048_/S VGND VGND VPWR VPWR _1043_/A sky130_fd_sc_hd__mux2_1
X_0826_ _1171_/A VGND VGND VPWR VPWR _0895_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_56_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_15_0_clk clkbuf_3_7_0_clk/X VGND VGND VPWR VPWR _1843_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1309_ _1682_/Q _1782_/Q _1315_/S VGND VGND VPWR VPWR _1310_/A sky130_fd_sc_hd__mux2_1
XFILLER_52_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1660_ _1763_/CLK _1660_/D _1417_/Y VGND VGND VPWR VPWR _1660_/Q sky130_fd_sc_hd__dfrtp_2
X_1591_ _1594_/A VGND VGND VPWR VPWR _1591_/Y sky130_fd_sc_hd__inv_2
XFILLER_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_4_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_4_9_0_clk/A sky130_fd_sc_hd__clkbuf_2
XFILLER_34_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1025_ _1024_/X _1786_/Q _1031_/S VGND VGND VPWR VPWR _1026_/A sky130_fd_sc_hd__mux2_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1789_ _1790_/CLK _1789_/D _1577_/Y VGND VGND VPWR VPWR _1789_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_44_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1643_ _1643_/A VGND VGND VPWR VPWR _1643_/Y sky130_fd_sc_hd__inv_2
XANTENNA_1 _1676_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1712_ _1817_/CLK _1712_/D _1481_/Y VGND VGND VPWR VPWR _1712_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1574_ _1575_/A VGND VGND VPWR VPWR _1574_/Y sky130_fd_sc_hd__inv_2
XFILLER_6_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1008_ _1007_/X _1791_/Q _1014_/S VGND VGND VPWR VPWR _1009_/A sky130_fd_sc_hd__mux2_1
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1290_ _1290_/A VGND VGND VPWR VPWR _1691_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1626_ _1638_/A VGND VGND VPWR VPWR _1631_/A sky130_fd_sc_hd__buf_2
XFILLER_31_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1557_ _1557_/A VGND VGND VPWR VPWR _1557_/Y sky130_fd_sc_hd__inv_2
X_1488_ _1488_/A VGND VGND VPWR VPWR _1488_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1411_ _1414_/A VGND VGND VPWR VPWR _1411_/Y sky130_fd_sc_hd__inv_2
X_1342_ _1342_/A VGND VGND VPWR VPWR _1668_/D sky130_fd_sc_hd__clkbuf_1
X_1273_ _1698_/Q _1798_/Q _1281_/S VGND VGND VPWR VPWR _1274_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0988_ _1797_/Q input49/X _0994_/S VGND VGND VPWR VPWR _0988_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1609_ _1612_/A VGND VGND VPWR VPWR _1609_/Y sky130_fd_sc_hd__inv_2
XFILLER_47_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0842_ _0893_/A VGND VGND VPWR VPWR _0856_/S sky130_fd_sc_hd__clkbuf_2
X_0911_ _0980_/A VGND VGND VPWR VPWR _0926_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1325_ _1325_/A VGND VGND VPWR VPWR _1675_/D sky130_fd_sc_hd__clkbuf_1
X_1256_ _1256_/A VGND VGND VPWR VPWR _1706_/D sky130_fd_sc_hd__clkbuf_1
X_1187_ _1187_/A VGND VGND VPWR VPWR _1737_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1110_ _1110_/A VGND VGND VPWR VPWR _1762_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1041_ _1782_/Q input32/X _1047_/S VGND VGND VPWR VPWR _1041_/X sky130_fd_sc_hd__mux2_1
X_0825_ input1/X VGND VGND VPWR VPWR _1171_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1308_ _1308_/A VGND VGND VPWR VPWR _1683_/D sky130_fd_sc_hd__clkbuf_1
X_1239_ _1272_/A VGND VGND VPWR VPWR _1248_/S sky130_fd_sc_hd__buf_2
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1590_ _1594_/A VGND VGND VPWR VPWR _1590_/Y sky130_fd_sc_hd__inv_2
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1024_ _1787_/Q input38/X _1030_/S VGND VGND VPWR VPWR _1024_/X sky130_fd_sc_hd__mux2_1
XFILLER_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1788_ _1793_/CLK _1788_/D _1575_/Y VGND VGND VPWR VPWR _1788_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_2 _1717_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1642_ _1643_/A VGND VGND VPWR VPWR _1642_/Y sky130_fd_sc_hd__inv_2
Xclkbuf_4_14_0_clk clkbuf_3_7_0_clk/X VGND VGND VPWR VPWR _1758_/CLK sky130_fd_sc_hd__clkbuf_2
X_1711_ _1817_/CLK _1711_/D _1480_/Y VGND VGND VPWR VPWR _1711_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1573_ _1575_/A VGND VGND VPWR VPWR _1573_/Y sky130_fd_sc_hd__inv_2
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1007_ _1792_/Q input43/X _1013_/S VGND VGND VPWR VPWR _1007_/X sky130_fd_sc_hd__mux2_1
XFILLER_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_3_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_4_7_0_clk/A sky130_fd_sc_hd__clkbuf_2
XFILLER_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1625_ _1625_/A VGND VGND VPWR VPWR _1625_/Y sky130_fd_sc_hd__inv_2
X_1556_ _1557_/A VGND VGND VPWR VPWR _1556_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1487_ _1488_/A VGND VGND VPWR VPWR _1487_/Y sky130_fd_sc_hd__inv_2
XFILLER_54_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1410_ _1414_/A VGND VGND VPWR VPWR _1410_/Y sky130_fd_sc_hd__inv_2
XFILLER_47_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1341_ _1668_/Q _1768_/Q _1349_/S VGND VGND VPWR VPWR _1342_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1272_ _1272_/A VGND VGND VPWR VPWR _1281_/S sky130_fd_sc_hd__buf_2
XFILLER_51_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0987_ _0987_/A VGND VGND VPWR VPWR _1797_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1539_ _1545_/A VGND VGND VPWR VPWR _1544_/A sky130_fd_sc_hd__buf_2
X_1608_ _1612_/A VGND VGND VPWR VPWR _1608_/Y sky130_fd_sc_hd__inv_2
XFILLER_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0841_ _0841_/A VGND VGND VPWR VPWR _1839_/D sky130_fd_sc_hd__clkbuf_1
X_0910_ _1084_/A VGND VGND VPWR VPWR _0980_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1186_ _1737_/Q _1837_/Q _1192_/S VGND VGND VPWR VPWR _1187_/A sky130_fd_sc_hd__mux2_1
X_1324_ _1675_/Q _1775_/Q _1326_/S VGND VGND VPWR VPWR _1325_/A sky130_fd_sc_hd__mux2_1
X_1255_ _1706_/Q _1806_/Q _1259_/S VGND VGND VPWR VPWR _1256_/A sky130_fd_sc_hd__mux2_1
XFILLER_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1040_ _1040_/A VGND VGND VPWR VPWR _1782_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_17_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0824_ _0824_/A0 _0824_/A1 _0839_/S VGND VGND VPWR VPWR _0824_/X sky130_fd_sc_hd__mux2_2
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1169_ _1168_/X _1744_/Q _1169_/S VGND VGND VPWR VPWR _1170_/A sky130_fd_sc_hd__mux2_1
X_1238_ _1238_/A VGND VGND VPWR VPWR _1714_/D sky130_fd_sc_hd__clkbuf_1
X_1307_ _1683_/Q _1783_/Q _1315_/S VGND VGND VPWR VPWR _1308_/A sky130_fd_sc_hd__mux2_1
XFILLER_20_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1023_ _1023_/A VGND VGND VPWR VPWR _1787_/D sky130_fd_sc_hd__clkbuf_1
X_1787_ _1793_/CLK _1787_/D _1574_/Y VGND VGND VPWR VPWR _1787_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1641_ _1643_/A VGND VGND VPWR VPWR _1641_/Y sky130_fd_sc_hd__inv_2
X_1710_ _1817_/CLK _1710_/D _1479_/Y VGND VGND VPWR VPWR _1710_/Q sky130_fd_sc_hd__dfrtp_1
XANTENNA_3 _1718_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1572_ _1575_/A VGND VGND VPWR VPWR _1572_/Y sky130_fd_sc_hd__inv_2
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1006_ _1006_/A VGND VGND VPWR VPWR _1792_/D sky130_fd_sc_hd__clkbuf_1
X_1839_ _1843_/CLK _1839_/D _1639_/Y VGND VGND VPWR VPWR _1839_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_22_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1624_ _1625_/A VGND VGND VPWR VPWR _1624_/Y sky130_fd_sc_hd__inv_2
XTAP_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1555_ _1557_/A VGND VGND VPWR VPWR _1555_/Y sky130_fd_sc_hd__inv_2
XFILLER_39_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1486_ _1488_/A VGND VGND VPWR VPWR _1486_/Y sky130_fd_sc_hd__inv_2
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_13_0_clk clkbuf_3_6_0_clk/X VGND VGND VPWR VPWR _1822_/CLK sky130_fd_sc_hd__clkbuf_2
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ _1384_/A VGND VGND VPWR VPWR _1349_/S sky130_fd_sc_hd__clkbuf_2
X_1271_ _1271_/A VGND VGND VPWR VPWR _1699_/D sky130_fd_sc_hd__clkbuf_1
X_0986_ _0985_/X _1797_/Q _0995_/S VGND VGND VPWR VPWR _0987_/A sky130_fd_sc_hd__mux2_1
X_1538_ _1538_/A VGND VGND VPWR VPWR _1538_/Y sky130_fd_sc_hd__inv_2
X_1469_ _1470_/A VGND VGND VPWR VPWR _1469_/Y sky130_fd_sc_hd__inv_2
X_1607_ _1607_/A VGND VGND VPWR VPWR _1612_/A sky130_fd_sc_hd__buf_2
XFILLER_27_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_2_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_4_5_0_clk/A sky130_fd_sc_hd__clkbuf_2
XFILLER_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0840_ _0839_/X _1839_/Q _0840_/S VGND VGND VPWR VPWR _0841_/A sky130_fd_sc_hd__mux2_1
XFILLER_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1323_ _1323_/A VGND VGND VPWR VPWR _1676_/D sky130_fd_sc_hd__clkbuf_1
X_1185_ _1185_/A VGND VGND VPWR VPWR _1738_/D sky130_fd_sc_hd__clkbuf_1
X_1254_ _1254_/A VGND VGND VPWR VPWR _1707_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_32_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0969_ _0968_/X _1802_/Q _0978_/S VGND VGND VPWR VPWR _0970_/A sky130_fd_sc_hd__mux2_1
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0823_ _0893_/A VGND VGND VPWR VPWR _0839_/S sky130_fd_sc_hd__clkbuf_4
XFILLER_28_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1306_ _1328_/A VGND VGND VPWR VPWR _1315_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_52_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1099_ _1099_/A VGND VGND VPWR VPWR _1765_/D sky130_fd_sc_hd__clkbuf_1
X_1168_ _1745_/Q input2/X _1168_/S VGND VGND VPWR VPWR _1168_/X sky130_fd_sc_hd__mux2_1
XFILLER_37_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1237_ _1714_/Q _1814_/Q _1237_/S VGND VGND VPWR VPWR _1238_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1022_ _1021_/X _1787_/Q _1031_/S VGND VGND VPWR VPWR _1023_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1786_ _1793_/CLK _1786_/D _1573_/Y VGND VGND VPWR VPWR _1786_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_55_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1640_ _1643_/A VGND VGND VPWR VPWR _1640_/Y sky130_fd_sc_hd__inv_2
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_4 _1735_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1571_ _1575_/A VGND VGND VPWR VPWR _1571_/Y sky130_fd_sc_hd__inv_2
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1005_ _1004_/X _1792_/Q _1014_/S VGND VGND VPWR VPWR _1006_/A sky130_fd_sc_hd__mux2_1
X_1838_ _1838_/CLK _1838_/D _1637_/Y VGND VGND VPWR VPWR _1838_/Q sky130_fd_sc_hd__dfrtp_1
X_1769_ _1772_/CLK _1769_/D _1553_/Y VGND VGND VPWR VPWR _1769_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_57_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1623_ _1625_/A VGND VGND VPWR VPWR _1623_/Y sky130_fd_sc_hd__inv_2
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1485_ _1488_/A VGND VGND VPWR VPWR _1485_/Y sky130_fd_sc_hd__inv_2
X_1554_ _1557_/A VGND VGND VPWR VPWR _1554_/Y sky130_fd_sc_hd__inv_2
.ends
